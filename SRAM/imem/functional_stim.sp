* Functional test stimulus file for 5ns period

* TT process corner
.include "/homes/rweic/ee526/ram_test_freepdk45_sapr_flow/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/homes/rweic/ee526/ram_test_freepdk45_sapr_flow/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "imem.sp"

* Global Power Supplies
Vvdd vdd 0 1.1

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Ximem din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 vdd gnd imem

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f

* Important signals for debug
* bl:	ximem.xbank0.bl_0_0
* br:	ximem.xbank0.br_0_0
* s_en:	ximem.s_en
* q:	ximem.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	ximem.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 01101011111110010111110000110111  to  address 11111101 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 00010001100111100010100000100000  to  address 00000011 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 11111101000101101110010000000011  to  address 00000011 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 11111101000101101110010000000011 from address 00000011 (from port 0) during cycle 4 (20ns - 25ns)
*	Writing 00111111100010000000011001010110  to  address 00000011 (from port 0) during cycle 5 (25ns - 30ns)
*	Writing 11111010110000111101000010010101  to  address 00000001 (from port 0) during cycle 6 (30ns - 35ns)
*	Reading 11111010110000111101000010010101 from address 00000001 (from port 0) during cycle 7 (35ns - 40ns)
*	Reading 01101011111110010111110000110111 from address 11111101 (from port 0) during cycle 8 (40ns - 45ns)
*	Reading 00111111100010000000011001010110 from address 00000011 (from port 0) during cycle 10 (50ns - 55ns)
*	Reading 00111111100010000000011001010110 from address 00000011 (from port 0) during cycle 11 (55ns - 60ns)
*	Reading 01101011111110010111110000110111 from address 11111101 (from port 0) during cycle 13 (65ns - 70ns)
*	Reading 00111111100010000000011001010110 from address 00000011 (from port 0) during cycle 14 (70ns - 75ns)
*	Writing 00000010101100110010000000010110  to  address 11111100 (from port 0) during cycle 15 (75ns - 80ns)
*	Reading 01101011111110010111110000110111 from address 11111101 (from port 0) during cycle 16 (80ns - 85ns)
*	Writing 00001000010100000011111010000110  to  address 11111101 (from port 0) during cycle 17 (85ns - 90ns)
*	Writing 10001011111010001010011000001100  to  address 00000010 (from port 0) during cycle 18 (90ns - 95ns)
*	Reading 11111010110000111101000010010101 from address 00000001 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 20 (100ns - 105ns)
*	Writing 11000000010001110000110001000000  to  address 00000010 (from port 0) during cycle 21 (105ns - 110ns)
*	Reading 00001000010100000011111010000110 from address 11111101 (from port 0) during cycle 22 (110ns - 115ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 25 (125ns - 130ns)
*	Reading 00111111100010000000011001010110 from address 00000011 (from port 0) during cycle 26 (130ns - 135ns)
*	Reading 11000000010001110000110001000000 from address 00000010 (from port 0) during cycle 27 (135ns - 140ns)
*	Writing 11010111100111110100111010111010  to  address 00000001 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 00111111100010000000011001010110 from address 00000011 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 00001000010100000011111010000110 from address 11111101 (from port 0) during cycle 32 (160ns - 165ns)
*	Reading 00111111100010000000011001010110 from address 00000011 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 11000000010001110000110001000000 from address 00000010 (from port 0) during cycle 34 (170ns - 175ns)
*	Reading 11010111100111110100111010111010 from address 00000001 (from port 0) during cycle 35 (175ns - 180ns)
*	Writing 01001000000001101100111100110100  to  address 00000011 (from port 0) during cycle 36 (180ns - 185ns)
*	Reading 00001000010100000011111010000110 from address 11111101 (from port 0) during cycle 37 (185ns - 190ns)
*	Writing 11110000111000000010000001001100  to  address 00000001 (from port 0) during cycle 38 (190ns - 195ns)
*	Reading 11110000111000000010000001001100 from address 00000001 (from port 0) during cycle 39 (195ns - 200ns)
*	Reading 11110000111000000010000001001100 from address 00000001 (from port 0) during cycle 40 (200ns - 205ns)
*	Reading 01001000000001101100111100110100 from address 00000011 (from port 0) during cycle 42 (210ns - 215ns)
*	Writing 01111100100100001000100111111101  to  address 00000011 (from port 0) during cycle 45 (225ns - 230ns)
*	Reading 01111100100100001000100111111101 from address 00000011 (from port 0) during cycle 49 (245ns - 250ns)
*	Writing 10110001011010000101100001010000  to  address 00000011 (from port 0) during cycle 50 (250ns - 255ns)
*	Reading 11110000111000000010000001001100 from address 00000001 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 53 (265ns - 270ns)
*	Writing 01110111001111010101111111001100  to  address 00000000 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 11110000111000000010000001001100 from address 00000001 (from port 0) during cycle 55 (275ns - 280ns)
*	Reading 11000000010001110000110001000000 from address 00000010 (from port 0) during cycle 56 (280ns - 285ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 58 (290ns - 295ns)
*	Writing 10010000110100101001101100100100  to  address 00000000 (from port 0) during cycle 59 (295ns - 300ns)
*	Reading 00001000010100000011111010000110 from address 11111101 (from port 0) during cycle 60 (300ns - 305ns)
*	Writing 10110101011110111110011101000010  to  address 00000011 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 11110000111000000010000001001100 from address 00000001 (from port 0) during cycle 62 (310ns - 315ns)
*	Writing 01111001000000100110000100101000  to  address 11111101 (from port 0) during cycle 63 (315ns - 320ns)
*	Reading 01111001000000100110000100101000 from address 11111101 (from port 0) during cycle 64 (320ns - 325ns)
*	Writing 01011110000101001101111010001110  to  address 00000001 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 01111001000000100110000100101000 from address 11111101 (from port 0) during cycle 67 (335ns - 340ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 11000000010001110000110001000000 from address 00000010 (from port 0) during cycle 70 (350ns - 355ns)
*	Reading 10110101011110111110011101000010 from address 00000011 (from port 0) during cycle 72 (360ns - 365ns)
*	Reading 01011110000101001101111010001110 from address 00000001 (from port 0) during cycle 73 (365ns - 370ns)
*	Writing 11001100010101010010001111111100  to  address 00000000 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 10110101011110111110011101000010 from address 00000011 (from port 0) during cycle 76 (380ns - 385ns)
*	Reading 11001100010101010010001111111100 from address 00000000 (from port 0) during cycle 77 (385ns - 390ns)
*	Writing 01011001101011011110011000111001  to  address 11111101 (from port 0) during cycle 78 (390ns - 395ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 01011110000101001101111010001110 from address 00000001 (from port 0) during cycle 81 (405ns - 410ns)
*	Reading 01011110000101001101111010001110 from address 00000001 (from port 0) during cycle 82 (410ns - 415ns)
*	Reading 01011001101011011110011000111001 from address 11111101 (from port 0) during cycle 83 (415ns - 420ns)
*	Reading 01011001101011011110011000111001 from address 11111101 (from port 0) during cycle 84 (420ns - 425ns)
*	Reading 01011110000101001101111010001110 from address 00000001 (from port 0) during cycle 85 (425ns - 430ns)
*	Reading 11000000010001110000110001000000 from address 00000010 (from port 0) during cycle 86 (430ns - 435ns)
*	Writing 11001000001101011110011111111101  to  address 11111011 (from port 0) during cycle 87 (435ns - 440ns)
*	Writing 00000001000111101000101101111001  to  address 00000010 (from port 0) during cycle 88 (440ns - 445ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 89 (445ns - 450ns)
*	Reading 00000001000111101000101101111001 from address 00000010 (from port 0) during cycle 90 (450ns - 455ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 91 (455ns - 460ns)
*	Reading 10110101011110111110011101000010 from address 00000011 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 11001000001101011110011111111101 from address 11111011 (from port 0) during cycle 93 (465ns - 470ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 94 (470ns - 475ns)
*	Reading 11001100010101010010001111111100 from address 00000000 (from port 0) during cycle 95 (475ns - 480ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 96 (480ns - 485ns)
*	Writing 01001001001110100001100110010011  to  address 00000011 (from port 0) during cycle 97 (485ns - 490ns)
*	Reading 00000010101100110010000000010110 from address 11111100 (from port 0) during cycle 98 (490ns - 495ns)
*	Writing 00100100010010010111100000001000  to  address 00000010 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 00100100010010010111100000001000 from address 00000010 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 01011110000101001101111010001110 from address 00000001 (from port 0) during cycle 103 (515ns - 520ns)
*	Writing 11001000000010011000111000000000  to  address 11111110 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 11001100010101010010001111111100 from address 00000000 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 01011001101011011110011000111001 from address 11111101 (from port 0) during cycle 108 (540ns - 545ns)
*	Writing 01001110000010010010101101111010  to  address 11111101 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 11001000001101011110011111111101 from address 11111011 (from port 0) during cycle 111 (555ns - 560ns)
*	Writing 10011000000000111110001110110101  to  address 11111100 (from port 0) during cycle 112 (560ns - 565ns)
*	Reading 11001000000010011000111000000000 from address 11111110 (from port 0) during cycle 113 (565ns - 570ns)
*	Reading 11001100010101010010001111111100 from address 00000000 (from port 0) during cycle 115 (575ns - 580ns)
*	Reading 11001000000010011000111000000000 from address 11111110 (from port 0) during cycle 117 (585ns - 590ns)
*	Writing 10100000011111010011110000111010  to  address 00000011 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 11001000000010011000111000000000 from address 11111110 (from port 0) during cycle 119 (595ns - 600ns)
*	Reading 10011000000000111110001110110101 from address 11111100 (from port 0) during cycle 120 (600ns - 605ns)
*	Reading 01011110000101001101111010001110 from address 00000001 (from port 0) during cycle 121 (605ns - 610ns)
*	Reading 11001000001101011110011111111101 from address 11111011 (from port 0) during cycle 122 (610ns - 615ns)
*	Reading 10011000000000111110001110110101 from address 11111100 (from port 0) during cycle 123 (615ns - 620ns)
*	Writing 10111111011000001111111001011001  to  address 00000010 (from port 0) during cycle 125 (625ns - 630ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 127 (635ns - 640ns)
*	Reading 11001000000010011000111000000000 from address 11111110 (from port 0) during cycle 128 (640ns - 645ns)
*	Reading 10011000000000111110001110110101 from address 11111100 (from port 0) during cycle 129 (645ns - 650ns)
*	Reading 01011110000101001101111010001110 from address 00000001 (from port 0) during cycle 131 (655ns - 660ns)
*	Writing 11001101001110011110100010101110  to  address 00000001 (from port 0) during cycle 135 (675ns - 680ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 137 (685ns - 690ns)
*	Writing 01011111011000111111011111100010  to  address 11111011 (from port 0) during cycle 138 (690ns - 695ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 139 (695ns - 700ns)
*	Reading 10111111011000001111111001011001 from address 00000010 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 10100000011111010011110000111010 from address 00000011 (from port 0) during cycle 141 (705ns - 710ns)
*	Reading 10011000000000111110001110110101 from address 11111100 (from port 0) during cycle 143 (715ns - 720ns)
*	Reading 10111111011000001111111001011001 from address 00000010 (from port 0) during cycle 145 (725ns - 730ns)
*	Reading 01011111011000111111011111100010 from address 11111011 (from port 0) during cycle 146 (730ns - 735ns)
*	Writing 11100100010110010110100101101001  to  address 00000000 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 11100100010110010110100101101001 from address 00000000 (from port 0) during cycle 148 (740ns - 745ns)
*	Reading 11001000000010011000111000000000 from address 11111110 (from port 0) during cycle 149 (745ns - 750ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 150 (750ns - 755ns)
*	Reading 10111111011000001111111001011001 from address 00000010 (from port 0) during cycle 151 (755ns - 760ns)
*	Reading 11001101001110011110100010101110 from address 00000001 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 11001000000010011000111000000000 from address 11111110 (from port 0) during cycle 153 (765ns - 770ns)
*	Reading 10100000011111010011110000111010 from address 00000011 (from port 0) during cycle 154 (770ns - 775ns)
*	Reading 11001101001110011110100010101110 from address 00000001 (from port 0) during cycle 155 (775ns - 780ns)
*	Reading 11100100010110010110100101101001 from address 00000000 (from port 0) during cycle 156 (780ns - 785ns)
*	Reading 01011111011000111111011111100010 from address 11111011 (from port 0) during cycle 158 (790ns - 795ns)
*	Writing 00111011111100101100000101000111  to  address 00000010 (from port 0) during cycle 159 (795ns - 800ns)
*	Reading 01011111011000111111011111100010 from address 11111011 (from port 0) during cycle 162 (810ns - 815ns)
*	Writing 00001110101010010101000011111110  to  address 11111110 (from port 0) during cycle 164 (820ns - 825ns)
*	Reading 11001101001110011110100010101110 from address 00000001 (from port 0) during cycle 165 (825ns - 830ns)
*	Reading 11100100010110010110100101101001 from address 00000000 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 11001101001110011110100010101110 from address 00000001 (from port 0) during cycle 167 (835ns - 840ns)
*	Writing 01100100111000001111101111001000  to  address 11111011 (from port 0) during cycle 168 (840ns - 845ns)
*	Writing 10010111000011001011000000001100  to  address 00000010 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 00001110101010010101000011111110 from address 11111110 (from port 0) during cycle 170 (850ns - 855ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 171 (855ns - 860ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 172 (860ns - 865ns)
*	Reading 10010111000011001011000000001100 from address 00000010 (from port 0) during cycle 173 (865ns - 870ns)
*	Reading 11001101001110011110100010101110 from address 00000001 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 176 (880ns - 885ns)
*	Writing 11010011101000111100100101100010  to  address 00000001 (from port 0) during cycle 177 (885ns - 890ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing 11010011011111000111000100101100  to  address 00000001 (from port 0) during cycle 180 (900ns - 905ns)
*	Writing 01110110101001001001111100100111  to  address 11111100 (from port 0) during cycle 183 (915ns - 920ns)
*	Reading 11010011011111000111000100101100 from address 00000001 (from port 0) during cycle 184 (920ns - 925ns)
*	Writing 01100010011111001011001101000101  to  address 11111100 (from port 0) during cycle 186 (930ns - 935ns)
*	Writing 00111001011100001010100111000101  to  address 00000010 (from port 0) during cycle 187 (935ns - 940ns)
*	Writing 00111111010111001010110011001110  to  address 00000000 (from port 0) during cycle 188 (940ns - 945ns)
*	Reading 10100000011111010011110000111010 from address 00000011 (from port 0) during cycle 192 (960ns - 965ns)
*	Reading 10100000011111010011110000111010 from address 00000011 (from port 0) during cycle 193 (965ns - 970ns)
*	Writing 10111110101100111101101110100010  to  address 00000001 (from port 0) during cycle 194 (970ns - 975ns)
*	Reading 01100100111000001111101111001000 from address 11111011 (from port 0) during cycle 195 (975ns - 980ns)
*	Writing 11001100011011100001000111000010  to  address 11111011 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 11001100011011100001000111000010 from address 11111011 (from port 0) during cycle 197 (985ns - 990ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 00111111010111001010110011001110 from address 00000000 (from port 0) during cycle 199 (995ns - 1000ns)
*	Reading 11001100011011100001000111000010 from address 11111011 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Reading 01001110000010010010101101111010 from address 11111101 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Writing 00000010010101001111000100010010  to  address 00000011 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Writing 01010100101111000000110010011001  to  address 00000010 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 0.0v 174.745n 0.0v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 1.1v 279.745n 1.1v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 1.1v 384.745n 1.1v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 0.0v 834.745n 0.0v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 1), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 1), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 0), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 1.1v 109.745n 1.1v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 1.1v 159.745n 1.1v 159.755n 0.0v 164.745n 0.0v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 0.0v 179.745n 0.0v 179.755n 1.1v 184.745n 1.1v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 1.1v 384.745n 1.1v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 0.0v 449.745n 0.0v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 1.1v 614.745n 1.1v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 0.0v 699.745n 0.0v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 0), (470, 1), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 1.1v 994.745n 1.1v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 0.0v 609.745n 0.0v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 0.0v 609.745n 0.0v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 0.0v 609.745n 0.0v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 0.0v 609.745n 0.0v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 0), (465, 1), (470, 1), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 0), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 0.0v 609.745n 0.0v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 1), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 0), (140, 1), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 0), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 1.1v 4.745n 1.1v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 1.1v 154.745n 1.1v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 1.1v 209.745n 1.1v 209.755n 0.0v 214.745n 0.0v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 1.1v 289.745n 1.1v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 1.1v 359.745n 1.1v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 0.0v 579.745n 0.0v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 1.1v 684.745n 1.1v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 0.0v 814.745n 0.0v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 1.1v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 1), (315, 0), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 1), (1020, 0), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 1.1v 4.745n 1.1v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 0.0v 319.745n 0.0v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 0.0v 889.745n 0.0v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 1.1v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 1.1 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.1 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 1.1 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 1.1 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 1.1 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 1.1 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 1.1 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 1.1 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 1.1 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 1.1 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 0 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 1.1 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 1.1 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 1.1 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 1.1 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 1.1 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 1.1 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 1.1 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_0 Vdout0_0ck7 = 1.1 time = 40
.meas tran vdout0_0ck7 FIND v(dout0_0) AT=40.025n

* CHECK dout0_1 Vdout0_1ck7 = 0 time = 40
.meas tran vdout0_1ck7 FIND v(dout0_1) AT=40.025n

* CHECK dout0_2 Vdout0_2ck7 = 1.1 time = 40
.meas tran vdout0_2ck7 FIND v(dout0_2) AT=40.025n

* CHECK dout0_3 Vdout0_3ck7 = 0 time = 40
.meas tran vdout0_3ck7 FIND v(dout0_3) AT=40.025n

* CHECK dout0_4 Vdout0_4ck7 = 1.1 time = 40
.meas tran vdout0_4ck7 FIND v(dout0_4) AT=40.025n

* CHECK dout0_5 Vdout0_5ck7 = 0 time = 40
.meas tran vdout0_5ck7 FIND v(dout0_5) AT=40.025n

* CHECK dout0_6 Vdout0_6ck7 = 0 time = 40
.meas tran vdout0_6ck7 FIND v(dout0_6) AT=40.025n

* CHECK dout0_7 Vdout0_7ck7 = 1.1 time = 40
.meas tran vdout0_7ck7 FIND v(dout0_7) AT=40.025n

* CHECK dout0_8 Vdout0_8ck7 = 0 time = 40
.meas tran vdout0_8ck7 FIND v(dout0_8) AT=40.025n

* CHECK dout0_9 Vdout0_9ck7 = 0 time = 40
.meas tran vdout0_9ck7 FIND v(dout0_9) AT=40.025n

* CHECK dout0_10 Vdout0_10ck7 = 0 time = 40
.meas tran vdout0_10ck7 FIND v(dout0_10) AT=40.025n

* CHECK dout0_11 Vdout0_11ck7 = 0 time = 40
.meas tran vdout0_11ck7 FIND v(dout0_11) AT=40.025n

* CHECK dout0_12 Vdout0_12ck7 = 1.1 time = 40
.meas tran vdout0_12ck7 FIND v(dout0_12) AT=40.025n

* CHECK dout0_13 Vdout0_13ck7 = 0 time = 40
.meas tran vdout0_13ck7 FIND v(dout0_13) AT=40.025n

* CHECK dout0_14 Vdout0_14ck7 = 1.1 time = 40
.meas tran vdout0_14ck7 FIND v(dout0_14) AT=40.025n

* CHECK dout0_15 Vdout0_15ck7 = 1.1 time = 40
.meas tran vdout0_15ck7 FIND v(dout0_15) AT=40.025n

* CHECK dout0_16 Vdout0_16ck7 = 1.1 time = 40
.meas tran vdout0_16ck7 FIND v(dout0_16) AT=40.025n

* CHECK dout0_17 Vdout0_17ck7 = 1.1 time = 40
.meas tran vdout0_17ck7 FIND v(dout0_17) AT=40.025n

* CHECK dout0_18 Vdout0_18ck7 = 0 time = 40
.meas tran vdout0_18ck7 FIND v(dout0_18) AT=40.025n

* CHECK dout0_19 Vdout0_19ck7 = 0 time = 40
.meas tran vdout0_19ck7 FIND v(dout0_19) AT=40.025n

* CHECK dout0_20 Vdout0_20ck7 = 0 time = 40
.meas tran vdout0_20ck7 FIND v(dout0_20) AT=40.025n

* CHECK dout0_21 Vdout0_21ck7 = 0 time = 40
.meas tran vdout0_21ck7 FIND v(dout0_21) AT=40.025n

* CHECK dout0_22 Vdout0_22ck7 = 1.1 time = 40
.meas tran vdout0_22ck7 FIND v(dout0_22) AT=40.025n

* CHECK dout0_23 Vdout0_23ck7 = 1.1 time = 40
.meas tran vdout0_23ck7 FIND v(dout0_23) AT=40.025n

* CHECK dout0_24 Vdout0_24ck7 = 0 time = 40
.meas tran vdout0_24ck7 FIND v(dout0_24) AT=40.025n

* CHECK dout0_25 Vdout0_25ck7 = 1.1 time = 40
.meas tran vdout0_25ck7 FIND v(dout0_25) AT=40.025n

* CHECK dout0_26 Vdout0_26ck7 = 0 time = 40
.meas tran vdout0_26ck7 FIND v(dout0_26) AT=40.025n

* CHECK dout0_27 Vdout0_27ck7 = 1.1 time = 40
.meas tran vdout0_27ck7 FIND v(dout0_27) AT=40.025n

* CHECK dout0_28 Vdout0_28ck7 = 1.1 time = 40
.meas tran vdout0_28ck7 FIND v(dout0_28) AT=40.025n

* CHECK dout0_29 Vdout0_29ck7 = 1.1 time = 40
.meas tran vdout0_29ck7 FIND v(dout0_29) AT=40.025n

* CHECK dout0_30 Vdout0_30ck7 = 1.1 time = 40
.meas tran vdout0_30ck7 FIND v(dout0_30) AT=40.025n

* CHECK dout0_31 Vdout0_31ck7 = 1.1 time = 40
.meas tran vdout0_31ck7 FIND v(dout0_31) AT=40.025n

* CHECK dout0_0 Vdout0_0ck8 = 1.1 time = 45
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=45.025n

* CHECK dout0_1 Vdout0_1ck8 = 1.1 time = 45
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=45.025n

* CHECK dout0_2 Vdout0_2ck8 = 1.1 time = 45
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=45.025n

* CHECK dout0_3 Vdout0_3ck8 = 0 time = 45
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=45.025n

* CHECK dout0_4 Vdout0_4ck8 = 1.1 time = 45
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=45.025n

* CHECK dout0_5 Vdout0_5ck8 = 1.1 time = 45
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=45.025n

* CHECK dout0_6 Vdout0_6ck8 = 0 time = 45
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=45.025n

* CHECK dout0_7 Vdout0_7ck8 = 0 time = 45
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=45.025n

* CHECK dout0_8 Vdout0_8ck8 = 0 time = 45
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=45.025n

* CHECK dout0_9 Vdout0_9ck8 = 0 time = 45
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=45.025n

* CHECK dout0_10 Vdout0_10ck8 = 1.1 time = 45
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=45.025n

* CHECK dout0_11 Vdout0_11ck8 = 1.1 time = 45
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=45.025n

* CHECK dout0_12 Vdout0_12ck8 = 1.1 time = 45
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=45.025n

* CHECK dout0_13 Vdout0_13ck8 = 1.1 time = 45
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=45.025n

* CHECK dout0_14 Vdout0_14ck8 = 1.1 time = 45
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=45.025n

* CHECK dout0_15 Vdout0_15ck8 = 0 time = 45
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=45.025n

* CHECK dout0_16 Vdout0_16ck8 = 1.1 time = 45
.meas tran vdout0_16ck8 FIND v(dout0_16) AT=45.025n

* CHECK dout0_17 Vdout0_17ck8 = 0 time = 45
.meas tran vdout0_17ck8 FIND v(dout0_17) AT=45.025n

* CHECK dout0_18 Vdout0_18ck8 = 0 time = 45
.meas tran vdout0_18ck8 FIND v(dout0_18) AT=45.025n

* CHECK dout0_19 Vdout0_19ck8 = 1.1 time = 45
.meas tran vdout0_19ck8 FIND v(dout0_19) AT=45.025n

* CHECK dout0_20 Vdout0_20ck8 = 1.1 time = 45
.meas tran vdout0_20ck8 FIND v(dout0_20) AT=45.025n

* CHECK dout0_21 Vdout0_21ck8 = 1.1 time = 45
.meas tran vdout0_21ck8 FIND v(dout0_21) AT=45.025n

* CHECK dout0_22 Vdout0_22ck8 = 1.1 time = 45
.meas tran vdout0_22ck8 FIND v(dout0_22) AT=45.025n

* CHECK dout0_23 Vdout0_23ck8 = 1.1 time = 45
.meas tran vdout0_23ck8 FIND v(dout0_23) AT=45.025n

* CHECK dout0_24 Vdout0_24ck8 = 1.1 time = 45
.meas tran vdout0_24ck8 FIND v(dout0_24) AT=45.025n

* CHECK dout0_25 Vdout0_25ck8 = 1.1 time = 45
.meas tran vdout0_25ck8 FIND v(dout0_25) AT=45.025n

* CHECK dout0_26 Vdout0_26ck8 = 0 time = 45
.meas tran vdout0_26ck8 FIND v(dout0_26) AT=45.025n

* CHECK dout0_27 Vdout0_27ck8 = 1.1 time = 45
.meas tran vdout0_27ck8 FIND v(dout0_27) AT=45.025n

* CHECK dout0_28 Vdout0_28ck8 = 0 time = 45
.meas tran vdout0_28ck8 FIND v(dout0_28) AT=45.025n

* CHECK dout0_29 Vdout0_29ck8 = 1.1 time = 45
.meas tran vdout0_29ck8 FIND v(dout0_29) AT=45.025n

* CHECK dout0_30 Vdout0_30ck8 = 1.1 time = 45
.meas tran vdout0_30ck8 FIND v(dout0_30) AT=45.025n

* CHECK dout0_31 Vdout0_31ck8 = 0 time = 45
.meas tran vdout0_31ck8 FIND v(dout0_31) AT=45.025n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 55
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=55.025n

* CHECK dout0_1 Vdout0_1ck10 = 1.1 time = 55
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=55.025n

* CHECK dout0_2 Vdout0_2ck10 = 1.1 time = 55
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=55.025n

* CHECK dout0_3 Vdout0_3ck10 = 0 time = 55
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=55.025n

* CHECK dout0_4 Vdout0_4ck10 = 1.1 time = 55
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=55.025n

* CHECK dout0_5 Vdout0_5ck10 = 0 time = 55
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=55.025n

* CHECK dout0_6 Vdout0_6ck10 = 1.1 time = 55
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=55.025n

* CHECK dout0_7 Vdout0_7ck10 = 0 time = 55
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=55.025n

* CHECK dout0_8 Vdout0_8ck10 = 0 time = 55
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=55.025n

* CHECK dout0_9 Vdout0_9ck10 = 1.1 time = 55
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=55.025n

* CHECK dout0_10 Vdout0_10ck10 = 1.1 time = 55
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=55.025n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 55
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=55.025n

* CHECK dout0_12 Vdout0_12ck10 = 0 time = 55
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=55.025n

* CHECK dout0_13 Vdout0_13ck10 = 0 time = 55
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=55.025n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 55
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=55.025n

* CHECK dout0_15 Vdout0_15ck10 = 0 time = 55
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=55.025n

* CHECK dout0_16 Vdout0_16ck10 = 0 time = 55
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=55.025n

* CHECK dout0_17 Vdout0_17ck10 = 0 time = 55
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=55.025n

* CHECK dout0_18 Vdout0_18ck10 = 0 time = 55
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=55.025n

* CHECK dout0_19 Vdout0_19ck10 = 1.1 time = 55
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=55.025n

* CHECK dout0_20 Vdout0_20ck10 = 0 time = 55
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=55.025n

* CHECK dout0_21 Vdout0_21ck10 = 0 time = 55
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=55.025n

* CHECK dout0_22 Vdout0_22ck10 = 0 time = 55
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=55.025n

* CHECK dout0_23 Vdout0_23ck10 = 1.1 time = 55
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=55.025n

* CHECK dout0_24 Vdout0_24ck10 = 1.1 time = 55
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=55.025n

* CHECK dout0_25 Vdout0_25ck10 = 1.1 time = 55
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=55.025n

* CHECK dout0_26 Vdout0_26ck10 = 1.1 time = 55
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=55.025n

* CHECK dout0_27 Vdout0_27ck10 = 1.1 time = 55
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=55.025n

* CHECK dout0_28 Vdout0_28ck10 = 1.1 time = 55
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=55.025n

* CHECK dout0_29 Vdout0_29ck10 = 1.1 time = 55
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=55.025n

* CHECK dout0_30 Vdout0_30ck10 = 0 time = 55
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=55.025n

* CHECK dout0_31 Vdout0_31ck10 = 0 time = 55
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=55.025n

* CHECK dout0_0 Vdout0_0ck11 = 0 time = 60
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=60.025n

* CHECK dout0_1 Vdout0_1ck11 = 1.1 time = 60
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=60.025n

* CHECK dout0_2 Vdout0_2ck11 = 1.1 time = 60
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=60.025n

* CHECK dout0_3 Vdout0_3ck11 = 0 time = 60
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=60.025n

* CHECK dout0_4 Vdout0_4ck11 = 1.1 time = 60
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=60.025n

* CHECK dout0_5 Vdout0_5ck11 = 0 time = 60
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=60.025n

* CHECK dout0_6 Vdout0_6ck11 = 1.1 time = 60
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=60.025n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 60
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=60.025n

* CHECK dout0_8 Vdout0_8ck11 = 0 time = 60
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=60.025n

* CHECK dout0_9 Vdout0_9ck11 = 1.1 time = 60
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=60.025n

* CHECK dout0_10 Vdout0_10ck11 = 1.1 time = 60
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=60.025n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 60
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=60.025n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 60
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=60.025n

* CHECK dout0_13 Vdout0_13ck11 = 0 time = 60
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=60.025n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 60
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=60.025n

* CHECK dout0_15 Vdout0_15ck11 = 0 time = 60
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=60.025n

* CHECK dout0_16 Vdout0_16ck11 = 0 time = 60
.meas tran vdout0_16ck11 FIND v(dout0_16) AT=60.025n

* CHECK dout0_17 Vdout0_17ck11 = 0 time = 60
.meas tran vdout0_17ck11 FIND v(dout0_17) AT=60.025n

* CHECK dout0_18 Vdout0_18ck11 = 0 time = 60
.meas tran vdout0_18ck11 FIND v(dout0_18) AT=60.025n

* CHECK dout0_19 Vdout0_19ck11 = 1.1 time = 60
.meas tran vdout0_19ck11 FIND v(dout0_19) AT=60.025n

* CHECK dout0_20 Vdout0_20ck11 = 0 time = 60
.meas tran vdout0_20ck11 FIND v(dout0_20) AT=60.025n

* CHECK dout0_21 Vdout0_21ck11 = 0 time = 60
.meas tran vdout0_21ck11 FIND v(dout0_21) AT=60.025n

* CHECK dout0_22 Vdout0_22ck11 = 0 time = 60
.meas tran vdout0_22ck11 FIND v(dout0_22) AT=60.025n

* CHECK dout0_23 Vdout0_23ck11 = 1.1 time = 60
.meas tran vdout0_23ck11 FIND v(dout0_23) AT=60.025n

* CHECK dout0_24 Vdout0_24ck11 = 1.1 time = 60
.meas tran vdout0_24ck11 FIND v(dout0_24) AT=60.025n

* CHECK dout0_25 Vdout0_25ck11 = 1.1 time = 60
.meas tran vdout0_25ck11 FIND v(dout0_25) AT=60.025n

* CHECK dout0_26 Vdout0_26ck11 = 1.1 time = 60
.meas tran vdout0_26ck11 FIND v(dout0_26) AT=60.025n

* CHECK dout0_27 Vdout0_27ck11 = 1.1 time = 60
.meas tran vdout0_27ck11 FIND v(dout0_27) AT=60.025n

* CHECK dout0_28 Vdout0_28ck11 = 1.1 time = 60
.meas tran vdout0_28ck11 FIND v(dout0_28) AT=60.025n

* CHECK dout0_29 Vdout0_29ck11 = 1.1 time = 60
.meas tran vdout0_29ck11 FIND v(dout0_29) AT=60.025n

* CHECK dout0_30 Vdout0_30ck11 = 0 time = 60
.meas tran vdout0_30ck11 FIND v(dout0_30) AT=60.025n

* CHECK dout0_31 Vdout0_31ck11 = 0 time = 60
.meas tran vdout0_31ck11 FIND v(dout0_31) AT=60.025n

* CHECK dout0_0 Vdout0_0ck13 = 1.1 time = 70
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=70.025n

* CHECK dout0_1 Vdout0_1ck13 = 1.1 time = 70
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=70.025n

* CHECK dout0_2 Vdout0_2ck13 = 1.1 time = 70
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=70.025n

* CHECK dout0_3 Vdout0_3ck13 = 0 time = 70
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=70.025n

* CHECK dout0_4 Vdout0_4ck13 = 1.1 time = 70
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=70.025n

* CHECK dout0_5 Vdout0_5ck13 = 1.1 time = 70
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=70.025n

* CHECK dout0_6 Vdout0_6ck13 = 0 time = 70
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=70.025n

* CHECK dout0_7 Vdout0_7ck13 = 0 time = 70
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=70.025n

* CHECK dout0_8 Vdout0_8ck13 = 0 time = 70
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=70.025n

* CHECK dout0_9 Vdout0_9ck13 = 0 time = 70
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=70.025n

* CHECK dout0_10 Vdout0_10ck13 = 1.1 time = 70
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=70.025n

* CHECK dout0_11 Vdout0_11ck13 = 1.1 time = 70
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=70.025n

* CHECK dout0_12 Vdout0_12ck13 = 1.1 time = 70
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=70.025n

* CHECK dout0_13 Vdout0_13ck13 = 1.1 time = 70
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=70.025n

* CHECK dout0_14 Vdout0_14ck13 = 1.1 time = 70
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=70.025n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 70
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=70.025n

* CHECK dout0_16 Vdout0_16ck13 = 1.1 time = 70
.meas tran vdout0_16ck13 FIND v(dout0_16) AT=70.025n

* CHECK dout0_17 Vdout0_17ck13 = 0 time = 70
.meas tran vdout0_17ck13 FIND v(dout0_17) AT=70.025n

* CHECK dout0_18 Vdout0_18ck13 = 0 time = 70
.meas tran vdout0_18ck13 FIND v(dout0_18) AT=70.025n

* CHECK dout0_19 Vdout0_19ck13 = 1.1 time = 70
.meas tran vdout0_19ck13 FIND v(dout0_19) AT=70.025n

* CHECK dout0_20 Vdout0_20ck13 = 1.1 time = 70
.meas tran vdout0_20ck13 FIND v(dout0_20) AT=70.025n

* CHECK dout0_21 Vdout0_21ck13 = 1.1 time = 70
.meas tran vdout0_21ck13 FIND v(dout0_21) AT=70.025n

* CHECK dout0_22 Vdout0_22ck13 = 1.1 time = 70
.meas tran vdout0_22ck13 FIND v(dout0_22) AT=70.025n

* CHECK dout0_23 Vdout0_23ck13 = 1.1 time = 70
.meas tran vdout0_23ck13 FIND v(dout0_23) AT=70.025n

* CHECK dout0_24 Vdout0_24ck13 = 1.1 time = 70
.meas tran vdout0_24ck13 FIND v(dout0_24) AT=70.025n

* CHECK dout0_25 Vdout0_25ck13 = 1.1 time = 70
.meas tran vdout0_25ck13 FIND v(dout0_25) AT=70.025n

* CHECK dout0_26 Vdout0_26ck13 = 0 time = 70
.meas tran vdout0_26ck13 FIND v(dout0_26) AT=70.025n

* CHECK dout0_27 Vdout0_27ck13 = 1.1 time = 70
.meas tran vdout0_27ck13 FIND v(dout0_27) AT=70.025n

* CHECK dout0_28 Vdout0_28ck13 = 0 time = 70
.meas tran vdout0_28ck13 FIND v(dout0_28) AT=70.025n

* CHECK dout0_29 Vdout0_29ck13 = 1.1 time = 70
.meas tran vdout0_29ck13 FIND v(dout0_29) AT=70.025n

* CHECK dout0_30 Vdout0_30ck13 = 1.1 time = 70
.meas tran vdout0_30ck13 FIND v(dout0_30) AT=70.025n

* CHECK dout0_31 Vdout0_31ck13 = 0 time = 70
.meas tran vdout0_31ck13 FIND v(dout0_31) AT=70.025n

* CHECK dout0_0 Vdout0_0ck14 = 0 time = 75
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=75.025n

* CHECK dout0_1 Vdout0_1ck14 = 1.1 time = 75
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=75.025n

* CHECK dout0_2 Vdout0_2ck14 = 1.1 time = 75
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=75.025n

* CHECK dout0_3 Vdout0_3ck14 = 0 time = 75
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=75.025n

* CHECK dout0_4 Vdout0_4ck14 = 1.1 time = 75
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=75.025n

* CHECK dout0_5 Vdout0_5ck14 = 0 time = 75
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=75.025n

* CHECK dout0_6 Vdout0_6ck14 = 1.1 time = 75
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=75.025n

* CHECK dout0_7 Vdout0_7ck14 = 0 time = 75
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=75.025n

* CHECK dout0_8 Vdout0_8ck14 = 0 time = 75
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=75.025n

* CHECK dout0_9 Vdout0_9ck14 = 1.1 time = 75
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=75.025n

* CHECK dout0_10 Vdout0_10ck14 = 1.1 time = 75
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=75.025n

* CHECK dout0_11 Vdout0_11ck14 = 0 time = 75
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=75.025n

* CHECK dout0_12 Vdout0_12ck14 = 0 time = 75
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=75.025n

* CHECK dout0_13 Vdout0_13ck14 = 0 time = 75
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=75.025n

* CHECK dout0_14 Vdout0_14ck14 = 0 time = 75
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=75.025n

* CHECK dout0_15 Vdout0_15ck14 = 0 time = 75
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=75.025n

* CHECK dout0_16 Vdout0_16ck14 = 0 time = 75
.meas tran vdout0_16ck14 FIND v(dout0_16) AT=75.025n

* CHECK dout0_17 Vdout0_17ck14 = 0 time = 75
.meas tran vdout0_17ck14 FIND v(dout0_17) AT=75.025n

* CHECK dout0_18 Vdout0_18ck14 = 0 time = 75
.meas tran vdout0_18ck14 FIND v(dout0_18) AT=75.025n

* CHECK dout0_19 Vdout0_19ck14 = 1.1 time = 75
.meas tran vdout0_19ck14 FIND v(dout0_19) AT=75.025n

* CHECK dout0_20 Vdout0_20ck14 = 0 time = 75
.meas tran vdout0_20ck14 FIND v(dout0_20) AT=75.025n

* CHECK dout0_21 Vdout0_21ck14 = 0 time = 75
.meas tran vdout0_21ck14 FIND v(dout0_21) AT=75.025n

* CHECK dout0_22 Vdout0_22ck14 = 0 time = 75
.meas tran vdout0_22ck14 FIND v(dout0_22) AT=75.025n

* CHECK dout0_23 Vdout0_23ck14 = 1.1 time = 75
.meas tran vdout0_23ck14 FIND v(dout0_23) AT=75.025n

* CHECK dout0_24 Vdout0_24ck14 = 1.1 time = 75
.meas tran vdout0_24ck14 FIND v(dout0_24) AT=75.025n

* CHECK dout0_25 Vdout0_25ck14 = 1.1 time = 75
.meas tran vdout0_25ck14 FIND v(dout0_25) AT=75.025n

* CHECK dout0_26 Vdout0_26ck14 = 1.1 time = 75
.meas tran vdout0_26ck14 FIND v(dout0_26) AT=75.025n

* CHECK dout0_27 Vdout0_27ck14 = 1.1 time = 75
.meas tran vdout0_27ck14 FIND v(dout0_27) AT=75.025n

* CHECK dout0_28 Vdout0_28ck14 = 1.1 time = 75
.meas tran vdout0_28ck14 FIND v(dout0_28) AT=75.025n

* CHECK dout0_29 Vdout0_29ck14 = 1.1 time = 75
.meas tran vdout0_29ck14 FIND v(dout0_29) AT=75.025n

* CHECK dout0_30 Vdout0_30ck14 = 0 time = 75
.meas tran vdout0_30ck14 FIND v(dout0_30) AT=75.025n

* CHECK dout0_31 Vdout0_31ck14 = 0 time = 75
.meas tran vdout0_31ck14 FIND v(dout0_31) AT=75.025n

* CHECK dout0_0 Vdout0_0ck16 = 1.1 time = 85
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=85.025n

* CHECK dout0_1 Vdout0_1ck16 = 1.1 time = 85
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=85.025n

* CHECK dout0_2 Vdout0_2ck16 = 1.1 time = 85
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=85.025n

* CHECK dout0_3 Vdout0_3ck16 = 0 time = 85
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=85.025n

* CHECK dout0_4 Vdout0_4ck16 = 1.1 time = 85
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=85.025n

* CHECK dout0_5 Vdout0_5ck16 = 1.1 time = 85
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=85.025n

* CHECK dout0_6 Vdout0_6ck16 = 0 time = 85
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=85.025n

* CHECK dout0_7 Vdout0_7ck16 = 0 time = 85
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=85.025n

* CHECK dout0_8 Vdout0_8ck16 = 0 time = 85
.meas tran vdout0_8ck16 FIND v(dout0_8) AT=85.025n

* CHECK dout0_9 Vdout0_9ck16 = 0 time = 85
.meas tran vdout0_9ck16 FIND v(dout0_9) AT=85.025n

* CHECK dout0_10 Vdout0_10ck16 = 1.1 time = 85
.meas tran vdout0_10ck16 FIND v(dout0_10) AT=85.025n

* CHECK dout0_11 Vdout0_11ck16 = 1.1 time = 85
.meas tran vdout0_11ck16 FIND v(dout0_11) AT=85.025n

* CHECK dout0_12 Vdout0_12ck16 = 1.1 time = 85
.meas tran vdout0_12ck16 FIND v(dout0_12) AT=85.025n

* CHECK dout0_13 Vdout0_13ck16 = 1.1 time = 85
.meas tran vdout0_13ck16 FIND v(dout0_13) AT=85.025n

* CHECK dout0_14 Vdout0_14ck16 = 1.1 time = 85
.meas tran vdout0_14ck16 FIND v(dout0_14) AT=85.025n

* CHECK dout0_15 Vdout0_15ck16 = 0 time = 85
.meas tran vdout0_15ck16 FIND v(dout0_15) AT=85.025n

* CHECK dout0_16 Vdout0_16ck16 = 1.1 time = 85
.meas tran vdout0_16ck16 FIND v(dout0_16) AT=85.025n

* CHECK dout0_17 Vdout0_17ck16 = 0 time = 85
.meas tran vdout0_17ck16 FIND v(dout0_17) AT=85.025n

* CHECK dout0_18 Vdout0_18ck16 = 0 time = 85
.meas tran vdout0_18ck16 FIND v(dout0_18) AT=85.025n

* CHECK dout0_19 Vdout0_19ck16 = 1.1 time = 85
.meas tran vdout0_19ck16 FIND v(dout0_19) AT=85.025n

* CHECK dout0_20 Vdout0_20ck16 = 1.1 time = 85
.meas tran vdout0_20ck16 FIND v(dout0_20) AT=85.025n

* CHECK dout0_21 Vdout0_21ck16 = 1.1 time = 85
.meas tran vdout0_21ck16 FIND v(dout0_21) AT=85.025n

* CHECK dout0_22 Vdout0_22ck16 = 1.1 time = 85
.meas tran vdout0_22ck16 FIND v(dout0_22) AT=85.025n

* CHECK dout0_23 Vdout0_23ck16 = 1.1 time = 85
.meas tran vdout0_23ck16 FIND v(dout0_23) AT=85.025n

* CHECK dout0_24 Vdout0_24ck16 = 1.1 time = 85
.meas tran vdout0_24ck16 FIND v(dout0_24) AT=85.025n

* CHECK dout0_25 Vdout0_25ck16 = 1.1 time = 85
.meas tran vdout0_25ck16 FIND v(dout0_25) AT=85.025n

* CHECK dout0_26 Vdout0_26ck16 = 0 time = 85
.meas tran vdout0_26ck16 FIND v(dout0_26) AT=85.025n

* CHECK dout0_27 Vdout0_27ck16 = 1.1 time = 85
.meas tran vdout0_27ck16 FIND v(dout0_27) AT=85.025n

* CHECK dout0_28 Vdout0_28ck16 = 0 time = 85
.meas tran vdout0_28ck16 FIND v(dout0_28) AT=85.025n

* CHECK dout0_29 Vdout0_29ck16 = 1.1 time = 85
.meas tran vdout0_29ck16 FIND v(dout0_29) AT=85.025n

* CHECK dout0_30 Vdout0_30ck16 = 1.1 time = 85
.meas tran vdout0_30ck16 FIND v(dout0_30) AT=85.025n

* CHECK dout0_31 Vdout0_31ck16 = 0 time = 85
.meas tran vdout0_31ck16 FIND v(dout0_31) AT=85.025n

* CHECK dout0_0 Vdout0_0ck19 = 1.1 time = 100
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=100.025n

* CHECK dout0_1 Vdout0_1ck19 = 0 time = 100
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=100.025n

* CHECK dout0_2 Vdout0_2ck19 = 1.1 time = 100
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=100.025n

* CHECK dout0_3 Vdout0_3ck19 = 0 time = 100
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=100.025n

* CHECK dout0_4 Vdout0_4ck19 = 1.1 time = 100
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=100.025n

* CHECK dout0_5 Vdout0_5ck19 = 0 time = 100
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=100.025n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 100
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=100.025n

* CHECK dout0_7 Vdout0_7ck19 = 1.1 time = 100
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=100.025n

* CHECK dout0_8 Vdout0_8ck19 = 0 time = 100
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=100.025n

* CHECK dout0_9 Vdout0_9ck19 = 0 time = 100
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=100.025n

* CHECK dout0_10 Vdout0_10ck19 = 0 time = 100
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=100.025n

* CHECK dout0_11 Vdout0_11ck19 = 0 time = 100
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=100.025n

* CHECK dout0_12 Vdout0_12ck19 = 1.1 time = 100
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=100.025n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 100
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=100.025n

* CHECK dout0_14 Vdout0_14ck19 = 1.1 time = 100
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=100.025n

* CHECK dout0_15 Vdout0_15ck19 = 1.1 time = 100
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=100.025n

* CHECK dout0_16 Vdout0_16ck19 = 1.1 time = 100
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=100.025n

* CHECK dout0_17 Vdout0_17ck19 = 1.1 time = 100
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=100.025n

* CHECK dout0_18 Vdout0_18ck19 = 0 time = 100
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=100.025n

* CHECK dout0_19 Vdout0_19ck19 = 0 time = 100
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=100.025n

* CHECK dout0_20 Vdout0_20ck19 = 0 time = 100
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=100.025n

* CHECK dout0_21 Vdout0_21ck19 = 0 time = 100
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=100.025n

* CHECK dout0_22 Vdout0_22ck19 = 1.1 time = 100
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=100.025n

* CHECK dout0_23 Vdout0_23ck19 = 1.1 time = 100
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=100.025n

* CHECK dout0_24 Vdout0_24ck19 = 0 time = 100
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=100.025n

* CHECK dout0_25 Vdout0_25ck19 = 1.1 time = 100
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=100.025n

* CHECK dout0_26 Vdout0_26ck19 = 0 time = 100
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=100.025n

* CHECK dout0_27 Vdout0_27ck19 = 1.1 time = 100
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=100.025n

* CHECK dout0_28 Vdout0_28ck19 = 1.1 time = 100
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=100.025n

* CHECK dout0_29 Vdout0_29ck19 = 1.1 time = 100
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=100.025n

* CHECK dout0_30 Vdout0_30ck19 = 1.1 time = 100
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=100.025n

* CHECK dout0_31 Vdout0_31ck19 = 1.1 time = 100
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=100.025n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 105
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=105.025n

* CHECK dout0_1 Vdout0_1ck20 = 1.1 time = 105
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=105.025n

* CHECK dout0_2 Vdout0_2ck20 = 1.1 time = 105
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=105.025n

* CHECK dout0_3 Vdout0_3ck20 = 0 time = 105
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=105.025n

* CHECK dout0_4 Vdout0_4ck20 = 1.1 time = 105
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=105.025n

* CHECK dout0_5 Vdout0_5ck20 = 0 time = 105
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=105.025n

* CHECK dout0_6 Vdout0_6ck20 = 0 time = 105
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=105.025n

* CHECK dout0_7 Vdout0_7ck20 = 0 time = 105
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=105.025n

* CHECK dout0_8 Vdout0_8ck20 = 0 time = 105
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=105.025n

* CHECK dout0_9 Vdout0_9ck20 = 0 time = 105
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=105.025n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 105
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=105.025n

* CHECK dout0_11 Vdout0_11ck20 = 0 time = 105
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=105.025n

* CHECK dout0_12 Vdout0_12ck20 = 0 time = 105
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=105.025n

* CHECK dout0_13 Vdout0_13ck20 = 1.1 time = 105
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=105.025n

* CHECK dout0_14 Vdout0_14ck20 = 0 time = 105
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=105.025n

* CHECK dout0_15 Vdout0_15ck20 = 0 time = 105
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=105.025n

* CHECK dout0_16 Vdout0_16ck20 = 1.1 time = 105
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=105.025n

* CHECK dout0_17 Vdout0_17ck20 = 1.1 time = 105
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=105.025n

* CHECK dout0_18 Vdout0_18ck20 = 0 time = 105
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=105.025n

* CHECK dout0_19 Vdout0_19ck20 = 0 time = 105
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=105.025n

* CHECK dout0_20 Vdout0_20ck20 = 1.1 time = 105
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=105.025n

* CHECK dout0_21 Vdout0_21ck20 = 1.1 time = 105
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=105.025n

* CHECK dout0_22 Vdout0_22ck20 = 0 time = 105
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=105.025n

* CHECK dout0_23 Vdout0_23ck20 = 1.1 time = 105
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=105.025n

* CHECK dout0_24 Vdout0_24ck20 = 0 time = 105
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=105.025n

* CHECK dout0_25 Vdout0_25ck20 = 1.1 time = 105
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=105.025n

* CHECK dout0_26 Vdout0_26ck20 = 0 time = 105
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=105.025n

* CHECK dout0_27 Vdout0_27ck20 = 0 time = 105
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=105.025n

* CHECK dout0_28 Vdout0_28ck20 = 0 time = 105
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=105.025n

* CHECK dout0_29 Vdout0_29ck20 = 0 time = 105
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=105.025n

* CHECK dout0_30 Vdout0_30ck20 = 0 time = 105
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=105.025n

* CHECK dout0_31 Vdout0_31ck20 = 0 time = 105
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=105.025n

* CHECK dout0_0 Vdout0_0ck22 = 0 time = 115
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=115.025n

* CHECK dout0_1 Vdout0_1ck22 = 1.1 time = 115
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=115.025n

* CHECK dout0_2 Vdout0_2ck22 = 1.1 time = 115
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=115.025n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 115
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=115.025n

* CHECK dout0_4 Vdout0_4ck22 = 0 time = 115
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=115.025n

* CHECK dout0_5 Vdout0_5ck22 = 0 time = 115
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=115.025n

* CHECK dout0_6 Vdout0_6ck22 = 0 time = 115
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=115.025n

* CHECK dout0_7 Vdout0_7ck22 = 1.1 time = 115
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=115.025n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 115
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=115.025n

* CHECK dout0_9 Vdout0_9ck22 = 1.1 time = 115
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=115.025n

* CHECK dout0_10 Vdout0_10ck22 = 1.1 time = 115
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=115.025n

* CHECK dout0_11 Vdout0_11ck22 = 1.1 time = 115
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=115.025n

* CHECK dout0_12 Vdout0_12ck22 = 1.1 time = 115
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=115.025n

* CHECK dout0_13 Vdout0_13ck22 = 1.1 time = 115
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=115.025n

* CHECK dout0_14 Vdout0_14ck22 = 0 time = 115
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=115.025n

* CHECK dout0_15 Vdout0_15ck22 = 0 time = 115
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=115.025n

* CHECK dout0_16 Vdout0_16ck22 = 0 time = 115
.meas tran vdout0_16ck22 FIND v(dout0_16) AT=115.025n

* CHECK dout0_17 Vdout0_17ck22 = 0 time = 115
.meas tran vdout0_17ck22 FIND v(dout0_17) AT=115.025n

* CHECK dout0_18 Vdout0_18ck22 = 0 time = 115
.meas tran vdout0_18ck22 FIND v(dout0_18) AT=115.025n

* CHECK dout0_19 Vdout0_19ck22 = 0 time = 115
.meas tran vdout0_19ck22 FIND v(dout0_19) AT=115.025n

* CHECK dout0_20 Vdout0_20ck22 = 1.1 time = 115
.meas tran vdout0_20ck22 FIND v(dout0_20) AT=115.025n

* CHECK dout0_21 Vdout0_21ck22 = 0 time = 115
.meas tran vdout0_21ck22 FIND v(dout0_21) AT=115.025n

* CHECK dout0_22 Vdout0_22ck22 = 1.1 time = 115
.meas tran vdout0_22ck22 FIND v(dout0_22) AT=115.025n

* CHECK dout0_23 Vdout0_23ck22 = 0 time = 115
.meas tran vdout0_23ck22 FIND v(dout0_23) AT=115.025n

* CHECK dout0_24 Vdout0_24ck22 = 0 time = 115
.meas tran vdout0_24ck22 FIND v(dout0_24) AT=115.025n

* CHECK dout0_25 Vdout0_25ck22 = 0 time = 115
.meas tran vdout0_25ck22 FIND v(dout0_25) AT=115.025n

* CHECK dout0_26 Vdout0_26ck22 = 0 time = 115
.meas tran vdout0_26ck22 FIND v(dout0_26) AT=115.025n

* CHECK dout0_27 Vdout0_27ck22 = 1.1 time = 115
.meas tran vdout0_27ck22 FIND v(dout0_27) AT=115.025n

* CHECK dout0_28 Vdout0_28ck22 = 0 time = 115
.meas tran vdout0_28ck22 FIND v(dout0_28) AT=115.025n

* CHECK dout0_29 Vdout0_29ck22 = 0 time = 115
.meas tran vdout0_29ck22 FIND v(dout0_29) AT=115.025n

* CHECK dout0_30 Vdout0_30ck22 = 0 time = 115
.meas tran vdout0_30ck22 FIND v(dout0_30) AT=115.025n

* CHECK dout0_31 Vdout0_31ck22 = 0 time = 115
.meas tran vdout0_31ck22 FIND v(dout0_31) AT=115.025n

* CHECK dout0_0 Vdout0_0ck23 = 0 time = 120
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=120.025n

* CHECK dout0_1 Vdout0_1ck23 = 1.1 time = 120
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=120.025n

* CHECK dout0_2 Vdout0_2ck23 = 1.1 time = 120
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=120.025n

* CHECK dout0_3 Vdout0_3ck23 = 0 time = 120
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=120.025n

* CHECK dout0_4 Vdout0_4ck23 = 1.1 time = 120
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=120.025n

* CHECK dout0_5 Vdout0_5ck23 = 0 time = 120
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=120.025n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 120
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=120.025n

* CHECK dout0_7 Vdout0_7ck23 = 0 time = 120
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=120.025n

* CHECK dout0_8 Vdout0_8ck23 = 0 time = 120
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=120.025n

* CHECK dout0_9 Vdout0_9ck23 = 0 time = 120
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=120.025n

* CHECK dout0_10 Vdout0_10ck23 = 0 time = 120
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=120.025n

* CHECK dout0_11 Vdout0_11ck23 = 0 time = 120
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=120.025n

* CHECK dout0_12 Vdout0_12ck23 = 0 time = 120
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=120.025n

* CHECK dout0_13 Vdout0_13ck23 = 1.1 time = 120
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=120.025n

* CHECK dout0_14 Vdout0_14ck23 = 0 time = 120
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=120.025n

* CHECK dout0_15 Vdout0_15ck23 = 0 time = 120
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=120.025n

* CHECK dout0_16 Vdout0_16ck23 = 1.1 time = 120
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=120.025n

* CHECK dout0_17 Vdout0_17ck23 = 1.1 time = 120
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=120.025n

* CHECK dout0_18 Vdout0_18ck23 = 0 time = 120
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=120.025n

* CHECK dout0_19 Vdout0_19ck23 = 0 time = 120
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=120.025n

* CHECK dout0_20 Vdout0_20ck23 = 1.1 time = 120
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=120.025n

* CHECK dout0_21 Vdout0_21ck23 = 1.1 time = 120
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=120.025n

* CHECK dout0_22 Vdout0_22ck23 = 0 time = 120
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=120.025n

* CHECK dout0_23 Vdout0_23ck23 = 1.1 time = 120
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=120.025n

* CHECK dout0_24 Vdout0_24ck23 = 0 time = 120
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=120.025n

* CHECK dout0_25 Vdout0_25ck23 = 1.1 time = 120
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=120.025n

* CHECK dout0_26 Vdout0_26ck23 = 0 time = 120
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=120.025n

* CHECK dout0_27 Vdout0_27ck23 = 0 time = 120
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=120.025n

* CHECK dout0_28 Vdout0_28ck23 = 0 time = 120
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=120.025n

* CHECK dout0_29 Vdout0_29ck23 = 0 time = 120
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=120.025n

* CHECK dout0_30 Vdout0_30ck23 = 0 time = 120
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=120.025n

* CHECK dout0_31 Vdout0_31ck23 = 0 time = 120
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=120.025n

* CHECK dout0_0 Vdout0_0ck25 = 0 time = 130
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=130.025n

* CHECK dout0_1 Vdout0_1ck25 = 1.1 time = 130
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=130.025n

* CHECK dout0_2 Vdout0_2ck25 = 1.1 time = 130
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=130.025n

* CHECK dout0_3 Vdout0_3ck25 = 0 time = 130
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=130.025n

* CHECK dout0_4 Vdout0_4ck25 = 1.1 time = 130
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=130.025n

* CHECK dout0_5 Vdout0_5ck25 = 0 time = 130
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=130.025n

* CHECK dout0_6 Vdout0_6ck25 = 0 time = 130
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=130.025n

* CHECK dout0_7 Vdout0_7ck25 = 0 time = 130
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=130.025n

* CHECK dout0_8 Vdout0_8ck25 = 0 time = 130
.meas tran vdout0_8ck25 FIND v(dout0_8) AT=130.025n

* CHECK dout0_9 Vdout0_9ck25 = 0 time = 130
.meas tran vdout0_9ck25 FIND v(dout0_9) AT=130.025n

* CHECK dout0_10 Vdout0_10ck25 = 0 time = 130
.meas tran vdout0_10ck25 FIND v(dout0_10) AT=130.025n

* CHECK dout0_11 Vdout0_11ck25 = 0 time = 130
.meas tran vdout0_11ck25 FIND v(dout0_11) AT=130.025n

* CHECK dout0_12 Vdout0_12ck25 = 0 time = 130
.meas tran vdout0_12ck25 FIND v(dout0_12) AT=130.025n

* CHECK dout0_13 Vdout0_13ck25 = 1.1 time = 130
.meas tran vdout0_13ck25 FIND v(dout0_13) AT=130.025n

* CHECK dout0_14 Vdout0_14ck25 = 0 time = 130
.meas tran vdout0_14ck25 FIND v(dout0_14) AT=130.025n

* CHECK dout0_15 Vdout0_15ck25 = 0 time = 130
.meas tran vdout0_15ck25 FIND v(dout0_15) AT=130.025n

* CHECK dout0_16 Vdout0_16ck25 = 1.1 time = 130
.meas tran vdout0_16ck25 FIND v(dout0_16) AT=130.025n

* CHECK dout0_17 Vdout0_17ck25 = 1.1 time = 130
.meas tran vdout0_17ck25 FIND v(dout0_17) AT=130.025n

* CHECK dout0_18 Vdout0_18ck25 = 0 time = 130
.meas tran vdout0_18ck25 FIND v(dout0_18) AT=130.025n

* CHECK dout0_19 Vdout0_19ck25 = 0 time = 130
.meas tran vdout0_19ck25 FIND v(dout0_19) AT=130.025n

* CHECK dout0_20 Vdout0_20ck25 = 1.1 time = 130
.meas tran vdout0_20ck25 FIND v(dout0_20) AT=130.025n

* CHECK dout0_21 Vdout0_21ck25 = 1.1 time = 130
.meas tran vdout0_21ck25 FIND v(dout0_21) AT=130.025n

* CHECK dout0_22 Vdout0_22ck25 = 0 time = 130
.meas tran vdout0_22ck25 FIND v(dout0_22) AT=130.025n

* CHECK dout0_23 Vdout0_23ck25 = 1.1 time = 130
.meas tran vdout0_23ck25 FIND v(dout0_23) AT=130.025n

* CHECK dout0_24 Vdout0_24ck25 = 0 time = 130
.meas tran vdout0_24ck25 FIND v(dout0_24) AT=130.025n

* CHECK dout0_25 Vdout0_25ck25 = 1.1 time = 130
.meas tran vdout0_25ck25 FIND v(dout0_25) AT=130.025n

* CHECK dout0_26 Vdout0_26ck25 = 0 time = 130
.meas tran vdout0_26ck25 FIND v(dout0_26) AT=130.025n

* CHECK dout0_27 Vdout0_27ck25 = 0 time = 130
.meas tran vdout0_27ck25 FIND v(dout0_27) AT=130.025n

* CHECK dout0_28 Vdout0_28ck25 = 0 time = 130
.meas tran vdout0_28ck25 FIND v(dout0_28) AT=130.025n

* CHECK dout0_29 Vdout0_29ck25 = 0 time = 130
.meas tran vdout0_29ck25 FIND v(dout0_29) AT=130.025n

* CHECK dout0_30 Vdout0_30ck25 = 0 time = 130
.meas tran vdout0_30ck25 FIND v(dout0_30) AT=130.025n

* CHECK dout0_31 Vdout0_31ck25 = 0 time = 130
.meas tran vdout0_31ck25 FIND v(dout0_31) AT=130.025n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 135
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=135.025n

* CHECK dout0_1 Vdout0_1ck26 = 1.1 time = 135
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=135.025n

* CHECK dout0_2 Vdout0_2ck26 = 1.1 time = 135
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=135.025n

* CHECK dout0_3 Vdout0_3ck26 = 0 time = 135
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=135.025n

* CHECK dout0_4 Vdout0_4ck26 = 1.1 time = 135
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=135.025n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 135
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=135.025n

* CHECK dout0_6 Vdout0_6ck26 = 1.1 time = 135
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=135.025n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 135
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=135.025n

* CHECK dout0_8 Vdout0_8ck26 = 0 time = 135
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=135.025n

* CHECK dout0_9 Vdout0_9ck26 = 1.1 time = 135
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=135.025n

* CHECK dout0_10 Vdout0_10ck26 = 1.1 time = 135
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=135.025n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 135
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=135.025n

* CHECK dout0_12 Vdout0_12ck26 = 0 time = 135
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=135.025n

* CHECK dout0_13 Vdout0_13ck26 = 0 time = 135
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=135.025n

* CHECK dout0_14 Vdout0_14ck26 = 0 time = 135
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=135.025n

* CHECK dout0_15 Vdout0_15ck26 = 0 time = 135
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=135.025n

* CHECK dout0_16 Vdout0_16ck26 = 0 time = 135
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=135.025n

* CHECK dout0_17 Vdout0_17ck26 = 0 time = 135
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=135.025n

* CHECK dout0_18 Vdout0_18ck26 = 0 time = 135
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=135.025n

* CHECK dout0_19 Vdout0_19ck26 = 1.1 time = 135
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=135.025n

* CHECK dout0_20 Vdout0_20ck26 = 0 time = 135
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=135.025n

* CHECK dout0_21 Vdout0_21ck26 = 0 time = 135
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=135.025n

* CHECK dout0_22 Vdout0_22ck26 = 0 time = 135
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=135.025n

* CHECK dout0_23 Vdout0_23ck26 = 1.1 time = 135
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=135.025n

* CHECK dout0_24 Vdout0_24ck26 = 1.1 time = 135
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=135.025n

* CHECK dout0_25 Vdout0_25ck26 = 1.1 time = 135
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=135.025n

* CHECK dout0_26 Vdout0_26ck26 = 1.1 time = 135
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=135.025n

* CHECK dout0_27 Vdout0_27ck26 = 1.1 time = 135
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=135.025n

* CHECK dout0_28 Vdout0_28ck26 = 1.1 time = 135
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=135.025n

* CHECK dout0_29 Vdout0_29ck26 = 1.1 time = 135
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=135.025n

* CHECK dout0_30 Vdout0_30ck26 = 0 time = 135
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=135.025n

* CHECK dout0_31 Vdout0_31ck26 = 0 time = 135
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=135.025n

* CHECK dout0_0 Vdout0_0ck27 = 0 time = 140
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=140.025n

* CHECK dout0_1 Vdout0_1ck27 = 0 time = 140
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=140.025n

* CHECK dout0_2 Vdout0_2ck27 = 0 time = 140
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=140.025n

* CHECK dout0_3 Vdout0_3ck27 = 0 time = 140
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=140.025n

* CHECK dout0_4 Vdout0_4ck27 = 0 time = 140
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=140.025n

* CHECK dout0_5 Vdout0_5ck27 = 0 time = 140
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=140.025n

* CHECK dout0_6 Vdout0_6ck27 = 1.1 time = 140
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=140.025n

* CHECK dout0_7 Vdout0_7ck27 = 0 time = 140
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=140.025n

* CHECK dout0_8 Vdout0_8ck27 = 0 time = 140
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=140.025n

* CHECK dout0_9 Vdout0_9ck27 = 0 time = 140
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=140.025n

* CHECK dout0_10 Vdout0_10ck27 = 1.1 time = 140
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=140.025n

* CHECK dout0_11 Vdout0_11ck27 = 1.1 time = 140
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=140.025n

* CHECK dout0_12 Vdout0_12ck27 = 0 time = 140
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=140.025n

* CHECK dout0_13 Vdout0_13ck27 = 0 time = 140
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=140.025n

* CHECK dout0_14 Vdout0_14ck27 = 0 time = 140
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=140.025n

* CHECK dout0_15 Vdout0_15ck27 = 0 time = 140
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=140.025n

* CHECK dout0_16 Vdout0_16ck27 = 1.1 time = 140
.meas tran vdout0_16ck27 FIND v(dout0_16) AT=140.025n

* CHECK dout0_17 Vdout0_17ck27 = 1.1 time = 140
.meas tran vdout0_17ck27 FIND v(dout0_17) AT=140.025n

* CHECK dout0_18 Vdout0_18ck27 = 1.1 time = 140
.meas tran vdout0_18ck27 FIND v(dout0_18) AT=140.025n

* CHECK dout0_19 Vdout0_19ck27 = 0 time = 140
.meas tran vdout0_19ck27 FIND v(dout0_19) AT=140.025n

* CHECK dout0_20 Vdout0_20ck27 = 0 time = 140
.meas tran vdout0_20ck27 FIND v(dout0_20) AT=140.025n

* CHECK dout0_21 Vdout0_21ck27 = 0 time = 140
.meas tran vdout0_21ck27 FIND v(dout0_21) AT=140.025n

* CHECK dout0_22 Vdout0_22ck27 = 1.1 time = 140
.meas tran vdout0_22ck27 FIND v(dout0_22) AT=140.025n

* CHECK dout0_23 Vdout0_23ck27 = 0 time = 140
.meas tran vdout0_23ck27 FIND v(dout0_23) AT=140.025n

* CHECK dout0_24 Vdout0_24ck27 = 0 time = 140
.meas tran vdout0_24ck27 FIND v(dout0_24) AT=140.025n

* CHECK dout0_25 Vdout0_25ck27 = 0 time = 140
.meas tran vdout0_25ck27 FIND v(dout0_25) AT=140.025n

* CHECK dout0_26 Vdout0_26ck27 = 0 time = 140
.meas tran vdout0_26ck27 FIND v(dout0_26) AT=140.025n

* CHECK dout0_27 Vdout0_27ck27 = 0 time = 140
.meas tran vdout0_27ck27 FIND v(dout0_27) AT=140.025n

* CHECK dout0_28 Vdout0_28ck27 = 0 time = 140
.meas tran vdout0_28ck27 FIND v(dout0_28) AT=140.025n

* CHECK dout0_29 Vdout0_29ck27 = 0 time = 140
.meas tran vdout0_29ck27 FIND v(dout0_29) AT=140.025n

* CHECK dout0_30 Vdout0_30ck27 = 1.1 time = 140
.meas tran vdout0_30ck27 FIND v(dout0_30) AT=140.025n

* CHECK dout0_31 Vdout0_31ck27 = 1.1 time = 140
.meas tran vdout0_31ck27 FIND v(dout0_31) AT=140.025n

* CHECK dout0_0 Vdout0_0ck31 = 0 time = 160
.meas tran vdout0_0ck31 FIND v(dout0_0) AT=160.025n

* CHECK dout0_1 Vdout0_1ck31 = 1.1 time = 160
.meas tran vdout0_1ck31 FIND v(dout0_1) AT=160.025n

* CHECK dout0_2 Vdout0_2ck31 = 1.1 time = 160
.meas tran vdout0_2ck31 FIND v(dout0_2) AT=160.025n

* CHECK dout0_3 Vdout0_3ck31 = 0 time = 160
.meas tran vdout0_3ck31 FIND v(dout0_3) AT=160.025n

* CHECK dout0_4 Vdout0_4ck31 = 1.1 time = 160
.meas tran vdout0_4ck31 FIND v(dout0_4) AT=160.025n

* CHECK dout0_5 Vdout0_5ck31 = 0 time = 160
.meas tran vdout0_5ck31 FIND v(dout0_5) AT=160.025n

* CHECK dout0_6 Vdout0_6ck31 = 1.1 time = 160
.meas tran vdout0_6ck31 FIND v(dout0_6) AT=160.025n

* CHECK dout0_7 Vdout0_7ck31 = 0 time = 160
.meas tran vdout0_7ck31 FIND v(dout0_7) AT=160.025n

* CHECK dout0_8 Vdout0_8ck31 = 0 time = 160
.meas tran vdout0_8ck31 FIND v(dout0_8) AT=160.025n

* CHECK dout0_9 Vdout0_9ck31 = 1.1 time = 160
.meas tran vdout0_9ck31 FIND v(dout0_9) AT=160.025n

* CHECK dout0_10 Vdout0_10ck31 = 1.1 time = 160
.meas tran vdout0_10ck31 FIND v(dout0_10) AT=160.025n

* CHECK dout0_11 Vdout0_11ck31 = 0 time = 160
.meas tran vdout0_11ck31 FIND v(dout0_11) AT=160.025n

* CHECK dout0_12 Vdout0_12ck31 = 0 time = 160
.meas tran vdout0_12ck31 FIND v(dout0_12) AT=160.025n

* CHECK dout0_13 Vdout0_13ck31 = 0 time = 160
.meas tran vdout0_13ck31 FIND v(dout0_13) AT=160.025n

* CHECK dout0_14 Vdout0_14ck31 = 0 time = 160
.meas tran vdout0_14ck31 FIND v(dout0_14) AT=160.025n

* CHECK dout0_15 Vdout0_15ck31 = 0 time = 160
.meas tran vdout0_15ck31 FIND v(dout0_15) AT=160.025n

* CHECK dout0_16 Vdout0_16ck31 = 0 time = 160
.meas tran vdout0_16ck31 FIND v(dout0_16) AT=160.025n

* CHECK dout0_17 Vdout0_17ck31 = 0 time = 160
.meas tran vdout0_17ck31 FIND v(dout0_17) AT=160.025n

* CHECK dout0_18 Vdout0_18ck31 = 0 time = 160
.meas tran vdout0_18ck31 FIND v(dout0_18) AT=160.025n

* CHECK dout0_19 Vdout0_19ck31 = 1.1 time = 160
.meas tran vdout0_19ck31 FIND v(dout0_19) AT=160.025n

* CHECK dout0_20 Vdout0_20ck31 = 0 time = 160
.meas tran vdout0_20ck31 FIND v(dout0_20) AT=160.025n

* CHECK dout0_21 Vdout0_21ck31 = 0 time = 160
.meas tran vdout0_21ck31 FIND v(dout0_21) AT=160.025n

* CHECK dout0_22 Vdout0_22ck31 = 0 time = 160
.meas tran vdout0_22ck31 FIND v(dout0_22) AT=160.025n

* CHECK dout0_23 Vdout0_23ck31 = 1.1 time = 160
.meas tran vdout0_23ck31 FIND v(dout0_23) AT=160.025n

* CHECK dout0_24 Vdout0_24ck31 = 1.1 time = 160
.meas tran vdout0_24ck31 FIND v(dout0_24) AT=160.025n

* CHECK dout0_25 Vdout0_25ck31 = 1.1 time = 160
.meas tran vdout0_25ck31 FIND v(dout0_25) AT=160.025n

* CHECK dout0_26 Vdout0_26ck31 = 1.1 time = 160
.meas tran vdout0_26ck31 FIND v(dout0_26) AT=160.025n

* CHECK dout0_27 Vdout0_27ck31 = 1.1 time = 160
.meas tran vdout0_27ck31 FIND v(dout0_27) AT=160.025n

* CHECK dout0_28 Vdout0_28ck31 = 1.1 time = 160
.meas tran vdout0_28ck31 FIND v(dout0_28) AT=160.025n

* CHECK dout0_29 Vdout0_29ck31 = 1.1 time = 160
.meas tran vdout0_29ck31 FIND v(dout0_29) AT=160.025n

* CHECK dout0_30 Vdout0_30ck31 = 0 time = 160
.meas tran vdout0_30ck31 FIND v(dout0_30) AT=160.025n

* CHECK dout0_31 Vdout0_31ck31 = 0 time = 160
.meas tran vdout0_31ck31 FIND v(dout0_31) AT=160.025n

* CHECK dout0_0 Vdout0_0ck32 = 0 time = 165
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=165.025n

* CHECK dout0_1 Vdout0_1ck32 = 1.1 time = 165
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=165.025n

* CHECK dout0_2 Vdout0_2ck32 = 1.1 time = 165
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=165.025n

* CHECK dout0_3 Vdout0_3ck32 = 0 time = 165
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=165.025n

* CHECK dout0_4 Vdout0_4ck32 = 0 time = 165
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=165.025n

* CHECK dout0_5 Vdout0_5ck32 = 0 time = 165
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=165.025n

* CHECK dout0_6 Vdout0_6ck32 = 0 time = 165
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=165.025n

* CHECK dout0_7 Vdout0_7ck32 = 1.1 time = 165
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=165.025n

* CHECK dout0_8 Vdout0_8ck32 = 0 time = 165
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=165.025n

* CHECK dout0_9 Vdout0_9ck32 = 1.1 time = 165
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=165.025n

* CHECK dout0_10 Vdout0_10ck32 = 1.1 time = 165
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=165.025n

* CHECK dout0_11 Vdout0_11ck32 = 1.1 time = 165
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=165.025n

* CHECK dout0_12 Vdout0_12ck32 = 1.1 time = 165
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=165.025n

* CHECK dout0_13 Vdout0_13ck32 = 1.1 time = 165
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=165.025n

* CHECK dout0_14 Vdout0_14ck32 = 0 time = 165
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=165.025n

* CHECK dout0_15 Vdout0_15ck32 = 0 time = 165
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=165.025n

* CHECK dout0_16 Vdout0_16ck32 = 0 time = 165
.meas tran vdout0_16ck32 FIND v(dout0_16) AT=165.025n

* CHECK dout0_17 Vdout0_17ck32 = 0 time = 165
.meas tran vdout0_17ck32 FIND v(dout0_17) AT=165.025n

* CHECK dout0_18 Vdout0_18ck32 = 0 time = 165
.meas tran vdout0_18ck32 FIND v(dout0_18) AT=165.025n

* CHECK dout0_19 Vdout0_19ck32 = 0 time = 165
.meas tran vdout0_19ck32 FIND v(dout0_19) AT=165.025n

* CHECK dout0_20 Vdout0_20ck32 = 1.1 time = 165
.meas tran vdout0_20ck32 FIND v(dout0_20) AT=165.025n

* CHECK dout0_21 Vdout0_21ck32 = 0 time = 165
.meas tran vdout0_21ck32 FIND v(dout0_21) AT=165.025n

* CHECK dout0_22 Vdout0_22ck32 = 1.1 time = 165
.meas tran vdout0_22ck32 FIND v(dout0_22) AT=165.025n

* CHECK dout0_23 Vdout0_23ck32 = 0 time = 165
.meas tran vdout0_23ck32 FIND v(dout0_23) AT=165.025n

* CHECK dout0_24 Vdout0_24ck32 = 0 time = 165
.meas tran vdout0_24ck32 FIND v(dout0_24) AT=165.025n

* CHECK dout0_25 Vdout0_25ck32 = 0 time = 165
.meas tran vdout0_25ck32 FIND v(dout0_25) AT=165.025n

* CHECK dout0_26 Vdout0_26ck32 = 0 time = 165
.meas tran vdout0_26ck32 FIND v(dout0_26) AT=165.025n

* CHECK dout0_27 Vdout0_27ck32 = 1.1 time = 165
.meas tran vdout0_27ck32 FIND v(dout0_27) AT=165.025n

* CHECK dout0_28 Vdout0_28ck32 = 0 time = 165
.meas tran vdout0_28ck32 FIND v(dout0_28) AT=165.025n

* CHECK dout0_29 Vdout0_29ck32 = 0 time = 165
.meas tran vdout0_29ck32 FIND v(dout0_29) AT=165.025n

* CHECK dout0_30 Vdout0_30ck32 = 0 time = 165
.meas tran vdout0_30ck32 FIND v(dout0_30) AT=165.025n

* CHECK dout0_31 Vdout0_31ck32 = 0 time = 165
.meas tran vdout0_31ck32 FIND v(dout0_31) AT=165.025n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 170
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=170.025n

* CHECK dout0_1 Vdout0_1ck33 = 1.1 time = 170
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=170.025n

* CHECK dout0_2 Vdout0_2ck33 = 1.1 time = 170
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=170.025n

* CHECK dout0_3 Vdout0_3ck33 = 0 time = 170
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=170.025n

* CHECK dout0_4 Vdout0_4ck33 = 1.1 time = 170
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=170.025n

* CHECK dout0_5 Vdout0_5ck33 = 0 time = 170
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=170.025n

* CHECK dout0_6 Vdout0_6ck33 = 1.1 time = 170
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=170.025n

* CHECK dout0_7 Vdout0_7ck33 = 0 time = 170
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=170.025n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 170
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=170.025n

* CHECK dout0_9 Vdout0_9ck33 = 1.1 time = 170
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=170.025n

* CHECK dout0_10 Vdout0_10ck33 = 1.1 time = 170
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=170.025n

* CHECK dout0_11 Vdout0_11ck33 = 0 time = 170
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=170.025n

* CHECK dout0_12 Vdout0_12ck33 = 0 time = 170
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=170.025n

* CHECK dout0_13 Vdout0_13ck33 = 0 time = 170
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=170.025n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 170
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=170.025n

* CHECK dout0_15 Vdout0_15ck33 = 0 time = 170
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=170.025n

* CHECK dout0_16 Vdout0_16ck33 = 0 time = 170
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=170.025n

* CHECK dout0_17 Vdout0_17ck33 = 0 time = 170
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=170.025n

* CHECK dout0_18 Vdout0_18ck33 = 0 time = 170
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=170.025n

* CHECK dout0_19 Vdout0_19ck33 = 1.1 time = 170
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=170.025n

* CHECK dout0_20 Vdout0_20ck33 = 0 time = 170
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=170.025n

* CHECK dout0_21 Vdout0_21ck33 = 0 time = 170
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=170.025n

* CHECK dout0_22 Vdout0_22ck33 = 0 time = 170
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=170.025n

* CHECK dout0_23 Vdout0_23ck33 = 1.1 time = 170
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=170.025n

* CHECK dout0_24 Vdout0_24ck33 = 1.1 time = 170
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=170.025n

* CHECK dout0_25 Vdout0_25ck33 = 1.1 time = 170
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=170.025n

* CHECK dout0_26 Vdout0_26ck33 = 1.1 time = 170
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=170.025n

* CHECK dout0_27 Vdout0_27ck33 = 1.1 time = 170
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=170.025n

* CHECK dout0_28 Vdout0_28ck33 = 1.1 time = 170
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=170.025n

* CHECK dout0_29 Vdout0_29ck33 = 1.1 time = 170
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=170.025n

* CHECK dout0_30 Vdout0_30ck33 = 0 time = 170
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=170.025n

* CHECK dout0_31 Vdout0_31ck33 = 0 time = 170
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=170.025n

* CHECK dout0_0 Vdout0_0ck34 = 0 time = 175
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=175.025n

* CHECK dout0_1 Vdout0_1ck34 = 0 time = 175
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=175.025n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 175
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=175.025n

* CHECK dout0_3 Vdout0_3ck34 = 0 time = 175
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=175.025n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 175
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=175.025n

* CHECK dout0_5 Vdout0_5ck34 = 0 time = 175
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=175.025n

* CHECK dout0_6 Vdout0_6ck34 = 1.1 time = 175
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=175.025n

* CHECK dout0_7 Vdout0_7ck34 = 0 time = 175
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=175.025n

* CHECK dout0_8 Vdout0_8ck34 = 0 time = 175
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=175.025n

* CHECK dout0_9 Vdout0_9ck34 = 0 time = 175
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=175.025n

* CHECK dout0_10 Vdout0_10ck34 = 1.1 time = 175
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=175.025n

* CHECK dout0_11 Vdout0_11ck34 = 1.1 time = 175
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=175.025n

* CHECK dout0_12 Vdout0_12ck34 = 0 time = 175
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=175.025n

* CHECK dout0_13 Vdout0_13ck34 = 0 time = 175
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=175.025n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 175
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=175.025n

* CHECK dout0_15 Vdout0_15ck34 = 0 time = 175
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=175.025n

* CHECK dout0_16 Vdout0_16ck34 = 1.1 time = 175
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=175.025n

* CHECK dout0_17 Vdout0_17ck34 = 1.1 time = 175
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=175.025n

* CHECK dout0_18 Vdout0_18ck34 = 1.1 time = 175
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=175.025n

* CHECK dout0_19 Vdout0_19ck34 = 0 time = 175
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=175.025n

* CHECK dout0_20 Vdout0_20ck34 = 0 time = 175
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=175.025n

* CHECK dout0_21 Vdout0_21ck34 = 0 time = 175
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=175.025n

* CHECK dout0_22 Vdout0_22ck34 = 1.1 time = 175
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=175.025n

* CHECK dout0_23 Vdout0_23ck34 = 0 time = 175
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=175.025n

* CHECK dout0_24 Vdout0_24ck34 = 0 time = 175
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=175.025n

* CHECK dout0_25 Vdout0_25ck34 = 0 time = 175
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=175.025n

* CHECK dout0_26 Vdout0_26ck34 = 0 time = 175
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=175.025n

* CHECK dout0_27 Vdout0_27ck34 = 0 time = 175
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=175.025n

* CHECK dout0_28 Vdout0_28ck34 = 0 time = 175
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=175.025n

* CHECK dout0_29 Vdout0_29ck34 = 0 time = 175
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=175.025n

* CHECK dout0_30 Vdout0_30ck34 = 1.1 time = 175
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=175.025n

* CHECK dout0_31 Vdout0_31ck34 = 1.1 time = 175
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=175.025n

* CHECK dout0_0 Vdout0_0ck35 = 0 time = 180
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=180.025n

* CHECK dout0_1 Vdout0_1ck35 = 1.1 time = 180
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=180.025n

* CHECK dout0_2 Vdout0_2ck35 = 0 time = 180
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=180.025n

* CHECK dout0_3 Vdout0_3ck35 = 1.1 time = 180
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=180.025n

* CHECK dout0_4 Vdout0_4ck35 = 1.1 time = 180
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=180.025n

* CHECK dout0_5 Vdout0_5ck35 = 1.1 time = 180
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=180.025n

* CHECK dout0_6 Vdout0_6ck35 = 0 time = 180
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=180.025n

* CHECK dout0_7 Vdout0_7ck35 = 1.1 time = 180
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=180.025n

* CHECK dout0_8 Vdout0_8ck35 = 0 time = 180
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=180.025n

* CHECK dout0_9 Vdout0_9ck35 = 1.1 time = 180
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=180.025n

* CHECK dout0_10 Vdout0_10ck35 = 1.1 time = 180
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=180.025n

* CHECK dout0_11 Vdout0_11ck35 = 1.1 time = 180
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=180.025n

* CHECK dout0_12 Vdout0_12ck35 = 0 time = 180
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=180.025n

* CHECK dout0_13 Vdout0_13ck35 = 0 time = 180
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=180.025n

* CHECK dout0_14 Vdout0_14ck35 = 1.1 time = 180
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=180.025n

* CHECK dout0_15 Vdout0_15ck35 = 0 time = 180
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=180.025n

* CHECK dout0_16 Vdout0_16ck35 = 1.1 time = 180
.meas tran vdout0_16ck35 FIND v(dout0_16) AT=180.025n

* CHECK dout0_17 Vdout0_17ck35 = 1.1 time = 180
.meas tran vdout0_17ck35 FIND v(dout0_17) AT=180.025n

* CHECK dout0_18 Vdout0_18ck35 = 1.1 time = 180
.meas tran vdout0_18ck35 FIND v(dout0_18) AT=180.025n

* CHECK dout0_19 Vdout0_19ck35 = 1.1 time = 180
.meas tran vdout0_19ck35 FIND v(dout0_19) AT=180.025n

* CHECK dout0_20 Vdout0_20ck35 = 1.1 time = 180
.meas tran vdout0_20ck35 FIND v(dout0_20) AT=180.025n

* CHECK dout0_21 Vdout0_21ck35 = 0 time = 180
.meas tran vdout0_21ck35 FIND v(dout0_21) AT=180.025n

* CHECK dout0_22 Vdout0_22ck35 = 0 time = 180
.meas tran vdout0_22ck35 FIND v(dout0_22) AT=180.025n

* CHECK dout0_23 Vdout0_23ck35 = 1.1 time = 180
.meas tran vdout0_23ck35 FIND v(dout0_23) AT=180.025n

* CHECK dout0_24 Vdout0_24ck35 = 1.1 time = 180
.meas tran vdout0_24ck35 FIND v(dout0_24) AT=180.025n

* CHECK dout0_25 Vdout0_25ck35 = 1.1 time = 180
.meas tran vdout0_25ck35 FIND v(dout0_25) AT=180.025n

* CHECK dout0_26 Vdout0_26ck35 = 1.1 time = 180
.meas tran vdout0_26ck35 FIND v(dout0_26) AT=180.025n

* CHECK dout0_27 Vdout0_27ck35 = 0 time = 180
.meas tran vdout0_27ck35 FIND v(dout0_27) AT=180.025n

* CHECK dout0_28 Vdout0_28ck35 = 1.1 time = 180
.meas tran vdout0_28ck35 FIND v(dout0_28) AT=180.025n

* CHECK dout0_29 Vdout0_29ck35 = 0 time = 180
.meas tran vdout0_29ck35 FIND v(dout0_29) AT=180.025n

* CHECK dout0_30 Vdout0_30ck35 = 1.1 time = 180
.meas tran vdout0_30ck35 FIND v(dout0_30) AT=180.025n

* CHECK dout0_31 Vdout0_31ck35 = 1.1 time = 180
.meas tran vdout0_31ck35 FIND v(dout0_31) AT=180.025n

* CHECK dout0_0 Vdout0_0ck37 = 0 time = 190
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=190.025n

* CHECK dout0_1 Vdout0_1ck37 = 1.1 time = 190
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=190.025n

* CHECK dout0_2 Vdout0_2ck37 = 1.1 time = 190
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=190.025n

* CHECK dout0_3 Vdout0_3ck37 = 0 time = 190
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=190.025n

* CHECK dout0_4 Vdout0_4ck37 = 0 time = 190
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=190.025n

* CHECK dout0_5 Vdout0_5ck37 = 0 time = 190
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=190.025n

* CHECK dout0_6 Vdout0_6ck37 = 0 time = 190
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=190.025n

* CHECK dout0_7 Vdout0_7ck37 = 1.1 time = 190
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=190.025n

* CHECK dout0_8 Vdout0_8ck37 = 0 time = 190
.meas tran vdout0_8ck37 FIND v(dout0_8) AT=190.025n

* CHECK dout0_9 Vdout0_9ck37 = 1.1 time = 190
.meas tran vdout0_9ck37 FIND v(dout0_9) AT=190.025n

* CHECK dout0_10 Vdout0_10ck37 = 1.1 time = 190
.meas tran vdout0_10ck37 FIND v(dout0_10) AT=190.025n

* CHECK dout0_11 Vdout0_11ck37 = 1.1 time = 190
.meas tran vdout0_11ck37 FIND v(dout0_11) AT=190.025n

* CHECK dout0_12 Vdout0_12ck37 = 1.1 time = 190
.meas tran vdout0_12ck37 FIND v(dout0_12) AT=190.025n

* CHECK dout0_13 Vdout0_13ck37 = 1.1 time = 190
.meas tran vdout0_13ck37 FIND v(dout0_13) AT=190.025n

* CHECK dout0_14 Vdout0_14ck37 = 0 time = 190
.meas tran vdout0_14ck37 FIND v(dout0_14) AT=190.025n

* CHECK dout0_15 Vdout0_15ck37 = 0 time = 190
.meas tran vdout0_15ck37 FIND v(dout0_15) AT=190.025n

* CHECK dout0_16 Vdout0_16ck37 = 0 time = 190
.meas tran vdout0_16ck37 FIND v(dout0_16) AT=190.025n

* CHECK dout0_17 Vdout0_17ck37 = 0 time = 190
.meas tran vdout0_17ck37 FIND v(dout0_17) AT=190.025n

* CHECK dout0_18 Vdout0_18ck37 = 0 time = 190
.meas tran vdout0_18ck37 FIND v(dout0_18) AT=190.025n

* CHECK dout0_19 Vdout0_19ck37 = 0 time = 190
.meas tran vdout0_19ck37 FIND v(dout0_19) AT=190.025n

* CHECK dout0_20 Vdout0_20ck37 = 1.1 time = 190
.meas tran vdout0_20ck37 FIND v(dout0_20) AT=190.025n

* CHECK dout0_21 Vdout0_21ck37 = 0 time = 190
.meas tran vdout0_21ck37 FIND v(dout0_21) AT=190.025n

* CHECK dout0_22 Vdout0_22ck37 = 1.1 time = 190
.meas tran vdout0_22ck37 FIND v(dout0_22) AT=190.025n

* CHECK dout0_23 Vdout0_23ck37 = 0 time = 190
.meas tran vdout0_23ck37 FIND v(dout0_23) AT=190.025n

* CHECK dout0_24 Vdout0_24ck37 = 0 time = 190
.meas tran vdout0_24ck37 FIND v(dout0_24) AT=190.025n

* CHECK dout0_25 Vdout0_25ck37 = 0 time = 190
.meas tran vdout0_25ck37 FIND v(dout0_25) AT=190.025n

* CHECK dout0_26 Vdout0_26ck37 = 0 time = 190
.meas tran vdout0_26ck37 FIND v(dout0_26) AT=190.025n

* CHECK dout0_27 Vdout0_27ck37 = 1.1 time = 190
.meas tran vdout0_27ck37 FIND v(dout0_27) AT=190.025n

* CHECK dout0_28 Vdout0_28ck37 = 0 time = 190
.meas tran vdout0_28ck37 FIND v(dout0_28) AT=190.025n

* CHECK dout0_29 Vdout0_29ck37 = 0 time = 190
.meas tran vdout0_29ck37 FIND v(dout0_29) AT=190.025n

* CHECK dout0_30 Vdout0_30ck37 = 0 time = 190
.meas tran vdout0_30ck37 FIND v(dout0_30) AT=190.025n

* CHECK dout0_31 Vdout0_31ck37 = 0 time = 190
.meas tran vdout0_31ck37 FIND v(dout0_31) AT=190.025n

* CHECK dout0_0 Vdout0_0ck39 = 0 time = 200
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=200.025n

* CHECK dout0_1 Vdout0_1ck39 = 0 time = 200
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=200.025n

* CHECK dout0_2 Vdout0_2ck39 = 1.1 time = 200
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=200.025n

* CHECK dout0_3 Vdout0_3ck39 = 1.1 time = 200
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=200.025n

* CHECK dout0_4 Vdout0_4ck39 = 0 time = 200
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=200.025n

* CHECK dout0_5 Vdout0_5ck39 = 0 time = 200
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=200.025n

* CHECK dout0_6 Vdout0_6ck39 = 1.1 time = 200
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=200.025n

* CHECK dout0_7 Vdout0_7ck39 = 0 time = 200
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=200.025n

* CHECK dout0_8 Vdout0_8ck39 = 0 time = 200
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=200.025n

* CHECK dout0_9 Vdout0_9ck39 = 0 time = 200
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=200.025n

* CHECK dout0_10 Vdout0_10ck39 = 0 time = 200
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=200.025n

* CHECK dout0_11 Vdout0_11ck39 = 0 time = 200
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=200.025n

* CHECK dout0_12 Vdout0_12ck39 = 0 time = 200
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=200.025n

* CHECK dout0_13 Vdout0_13ck39 = 1.1 time = 200
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=200.025n

* CHECK dout0_14 Vdout0_14ck39 = 0 time = 200
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=200.025n

* CHECK dout0_15 Vdout0_15ck39 = 0 time = 200
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=200.025n

* CHECK dout0_16 Vdout0_16ck39 = 0 time = 200
.meas tran vdout0_16ck39 FIND v(dout0_16) AT=200.025n

* CHECK dout0_17 Vdout0_17ck39 = 0 time = 200
.meas tran vdout0_17ck39 FIND v(dout0_17) AT=200.025n

* CHECK dout0_18 Vdout0_18ck39 = 0 time = 200
.meas tran vdout0_18ck39 FIND v(dout0_18) AT=200.025n

* CHECK dout0_19 Vdout0_19ck39 = 0 time = 200
.meas tran vdout0_19ck39 FIND v(dout0_19) AT=200.025n

* CHECK dout0_20 Vdout0_20ck39 = 0 time = 200
.meas tran vdout0_20ck39 FIND v(dout0_20) AT=200.025n

* CHECK dout0_21 Vdout0_21ck39 = 1.1 time = 200
.meas tran vdout0_21ck39 FIND v(dout0_21) AT=200.025n

* CHECK dout0_22 Vdout0_22ck39 = 1.1 time = 200
.meas tran vdout0_22ck39 FIND v(dout0_22) AT=200.025n

* CHECK dout0_23 Vdout0_23ck39 = 1.1 time = 200
.meas tran vdout0_23ck39 FIND v(dout0_23) AT=200.025n

* CHECK dout0_24 Vdout0_24ck39 = 0 time = 200
.meas tran vdout0_24ck39 FIND v(dout0_24) AT=200.025n

* CHECK dout0_25 Vdout0_25ck39 = 0 time = 200
.meas tran vdout0_25ck39 FIND v(dout0_25) AT=200.025n

* CHECK dout0_26 Vdout0_26ck39 = 0 time = 200
.meas tran vdout0_26ck39 FIND v(dout0_26) AT=200.025n

* CHECK dout0_27 Vdout0_27ck39 = 0 time = 200
.meas tran vdout0_27ck39 FIND v(dout0_27) AT=200.025n

* CHECK dout0_28 Vdout0_28ck39 = 1.1 time = 200
.meas tran vdout0_28ck39 FIND v(dout0_28) AT=200.025n

* CHECK dout0_29 Vdout0_29ck39 = 1.1 time = 200
.meas tran vdout0_29ck39 FIND v(dout0_29) AT=200.025n

* CHECK dout0_30 Vdout0_30ck39 = 1.1 time = 200
.meas tran vdout0_30ck39 FIND v(dout0_30) AT=200.025n

* CHECK dout0_31 Vdout0_31ck39 = 1.1 time = 200
.meas tran vdout0_31ck39 FIND v(dout0_31) AT=200.025n

* CHECK dout0_0 Vdout0_0ck40 = 0 time = 205
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=205.025n

* CHECK dout0_1 Vdout0_1ck40 = 0 time = 205
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=205.025n

* CHECK dout0_2 Vdout0_2ck40 = 1.1 time = 205
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=205.025n

* CHECK dout0_3 Vdout0_3ck40 = 1.1 time = 205
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=205.025n

* CHECK dout0_4 Vdout0_4ck40 = 0 time = 205
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=205.025n

* CHECK dout0_5 Vdout0_5ck40 = 0 time = 205
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=205.025n

* CHECK dout0_6 Vdout0_6ck40 = 1.1 time = 205
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=205.025n

* CHECK dout0_7 Vdout0_7ck40 = 0 time = 205
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=205.025n

* CHECK dout0_8 Vdout0_8ck40 = 0 time = 205
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=205.025n

* CHECK dout0_9 Vdout0_9ck40 = 0 time = 205
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=205.025n

* CHECK dout0_10 Vdout0_10ck40 = 0 time = 205
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=205.025n

* CHECK dout0_11 Vdout0_11ck40 = 0 time = 205
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=205.025n

* CHECK dout0_12 Vdout0_12ck40 = 0 time = 205
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=205.025n

* CHECK dout0_13 Vdout0_13ck40 = 1.1 time = 205
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=205.025n

* CHECK dout0_14 Vdout0_14ck40 = 0 time = 205
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=205.025n

* CHECK dout0_15 Vdout0_15ck40 = 0 time = 205
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=205.025n

* CHECK dout0_16 Vdout0_16ck40 = 0 time = 205
.meas tran vdout0_16ck40 FIND v(dout0_16) AT=205.025n

* CHECK dout0_17 Vdout0_17ck40 = 0 time = 205
.meas tran vdout0_17ck40 FIND v(dout0_17) AT=205.025n

* CHECK dout0_18 Vdout0_18ck40 = 0 time = 205
.meas tran vdout0_18ck40 FIND v(dout0_18) AT=205.025n

* CHECK dout0_19 Vdout0_19ck40 = 0 time = 205
.meas tran vdout0_19ck40 FIND v(dout0_19) AT=205.025n

* CHECK dout0_20 Vdout0_20ck40 = 0 time = 205
.meas tran vdout0_20ck40 FIND v(dout0_20) AT=205.025n

* CHECK dout0_21 Vdout0_21ck40 = 1.1 time = 205
.meas tran vdout0_21ck40 FIND v(dout0_21) AT=205.025n

* CHECK dout0_22 Vdout0_22ck40 = 1.1 time = 205
.meas tran vdout0_22ck40 FIND v(dout0_22) AT=205.025n

* CHECK dout0_23 Vdout0_23ck40 = 1.1 time = 205
.meas tran vdout0_23ck40 FIND v(dout0_23) AT=205.025n

* CHECK dout0_24 Vdout0_24ck40 = 0 time = 205
.meas tran vdout0_24ck40 FIND v(dout0_24) AT=205.025n

* CHECK dout0_25 Vdout0_25ck40 = 0 time = 205
.meas tran vdout0_25ck40 FIND v(dout0_25) AT=205.025n

* CHECK dout0_26 Vdout0_26ck40 = 0 time = 205
.meas tran vdout0_26ck40 FIND v(dout0_26) AT=205.025n

* CHECK dout0_27 Vdout0_27ck40 = 0 time = 205
.meas tran vdout0_27ck40 FIND v(dout0_27) AT=205.025n

* CHECK dout0_28 Vdout0_28ck40 = 1.1 time = 205
.meas tran vdout0_28ck40 FIND v(dout0_28) AT=205.025n

* CHECK dout0_29 Vdout0_29ck40 = 1.1 time = 205
.meas tran vdout0_29ck40 FIND v(dout0_29) AT=205.025n

* CHECK dout0_30 Vdout0_30ck40 = 1.1 time = 205
.meas tran vdout0_30ck40 FIND v(dout0_30) AT=205.025n

* CHECK dout0_31 Vdout0_31ck40 = 1.1 time = 205
.meas tran vdout0_31ck40 FIND v(dout0_31) AT=205.025n

* CHECK dout0_0 Vdout0_0ck42 = 0 time = 215
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=215.025n

* CHECK dout0_1 Vdout0_1ck42 = 0 time = 215
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=215.025n

* CHECK dout0_2 Vdout0_2ck42 = 1.1 time = 215
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=215.025n

* CHECK dout0_3 Vdout0_3ck42 = 0 time = 215
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=215.025n

* CHECK dout0_4 Vdout0_4ck42 = 1.1 time = 215
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=215.025n

* CHECK dout0_5 Vdout0_5ck42 = 1.1 time = 215
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=215.025n

* CHECK dout0_6 Vdout0_6ck42 = 0 time = 215
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=215.025n

* CHECK dout0_7 Vdout0_7ck42 = 0 time = 215
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=215.025n

* CHECK dout0_8 Vdout0_8ck42 = 1.1 time = 215
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=215.025n

* CHECK dout0_9 Vdout0_9ck42 = 1.1 time = 215
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=215.025n

* CHECK dout0_10 Vdout0_10ck42 = 1.1 time = 215
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=215.025n

* CHECK dout0_11 Vdout0_11ck42 = 1.1 time = 215
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=215.025n

* CHECK dout0_12 Vdout0_12ck42 = 0 time = 215
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=215.025n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 215
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=215.025n

* CHECK dout0_14 Vdout0_14ck42 = 1.1 time = 215
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=215.025n

* CHECK dout0_15 Vdout0_15ck42 = 1.1 time = 215
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=215.025n

* CHECK dout0_16 Vdout0_16ck42 = 0 time = 215
.meas tran vdout0_16ck42 FIND v(dout0_16) AT=215.025n

* CHECK dout0_17 Vdout0_17ck42 = 1.1 time = 215
.meas tran vdout0_17ck42 FIND v(dout0_17) AT=215.025n

* CHECK dout0_18 Vdout0_18ck42 = 1.1 time = 215
.meas tran vdout0_18ck42 FIND v(dout0_18) AT=215.025n

* CHECK dout0_19 Vdout0_19ck42 = 0 time = 215
.meas tran vdout0_19ck42 FIND v(dout0_19) AT=215.025n

* CHECK dout0_20 Vdout0_20ck42 = 0 time = 215
.meas tran vdout0_20ck42 FIND v(dout0_20) AT=215.025n

* CHECK dout0_21 Vdout0_21ck42 = 0 time = 215
.meas tran vdout0_21ck42 FIND v(dout0_21) AT=215.025n

* CHECK dout0_22 Vdout0_22ck42 = 0 time = 215
.meas tran vdout0_22ck42 FIND v(dout0_22) AT=215.025n

* CHECK dout0_23 Vdout0_23ck42 = 0 time = 215
.meas tran vdout0_23ck42 FIND v(dout0_23) AT=215.025n

* CHECK dout0_24 Vdout0_24ck42 = 0 time = 215
.meas tran vdout0_24ck42 FIND v(dout0_24) AT=215.025n

* CHECK dout0_25 Vdout0_25ck42 = 0 time = 215
.meas tran vdout0_25ck42 FIND v(dout0_25) AT=215.025n

* CHECK dout0_26 Vdout0_26ck42 = 0 time = 215
.meas tran vdout0_26ck42 FIND v(dout0_26) AT=215.025n

* CHECK dout0_27 Vdout0_27ck42 = 1.1 time = 215
.meas tran vdout0_27ck42 FIND v(dout0_27) AT=215.025n

* CHECK dout0_28 Vdout0_28ck42 = 0 time = 215
.meas tran vdout0_28ck42 FIND v(dout0_28) AT=215.025n

* CHECK dout0_29 Vdout0_29ck42 = 0 time = 215
.meas tran vdout0_29ck42 FIND v(dout0_29) AT=215.025n

* CHECK dout0_30 Vdout0_30ck42 = 1.1 time = 215
.meas tran vdout0_30ck42 FIND v(dout0_30) AT=215.025n

* CHECK dout0_31 Vdout0_31ck42 = 0 time = 215
.meas tran vdout0_31ck42 FIND v(dout0_31) AT=215.025n

* CHECK dout0_0 Vdout0_0ck49 = 1.1 time = 250
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=250.025n

* CHECK dout0_1 Vdout0_1ck49 = 0 time = 250
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=250.025n

* CHECK dout0_2 Vdout0_2ck49 = 1.1 time = 250
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=250.025n

* CHECK dout0_3 Vdout0_3ck49 = 1.1 time = 250
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=250.025n

* CHECK dout0_4 Vdout0_4ck49 = 1.1 time = 250
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=250.025n

* CHECK dout0_5 Vdout0_5ck49 = 1.1 time = 250
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=250.025n

* CHECK dout0_6 Vdout0_6ck49 = 1.1 time = 250
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=250.025n

* CHECK dout0_7 Vdout0_7ck49 = 1.1 time = 250
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=250.025n

* CHECK dout0_8 Vdout0_8ck49 = 1.1 time = 250
.meas tran vdout0_8ck49 FIND v(dout0_8) AT=250.025n

* CHECK dout0_9 Vdout0_9ck49 = 0 time = 250
.meas tran vdout0_9ck49 FIND v(dout0_9) AT=250.025n

* CHECK dout0_10 Vdout0_10ck49 = 0 time = 250
.meas tran vdout0_10ck49 FIND v(dout0_10) AT=250.025n

* CHECK dout0_11 Vdout0_11ck49 = 1.1 time = 250
.meas tran vdout0_11ck49 FIND v(dout0_11) AT=250.025n

* CHECK dout0_12 Vdout0_12ck49 = 0 time = 250
.meas tran vdout0_12ck49 FIND v(dout0_12) AT=250.025n

* CHECK dout0_13 Vdout0_13ck49 = 0 time = 250
.meas tran vdout0_13ck49 FIND v(dout0_13) AT=250.025n

* CHECK dout0_14 Vdout0_14ck49 = 0 time = 250
.meas tran vdout0_14ck49 FIND v(dout0_14) AT=250.025n

* CHECK dout0_15 Vdout0_15ck49 = 1.1 time = 250
.meas tran vdout0_15ck49 FIND v(dout0_15) AT=250.025n

* CHECK dout0_16 Vdout0_16ck49 = 0 time = 250
.meas tran vdout0_16ck49 FIND v(dout0_16) AT=250.025n

* CHECK dout0_17 Vdout0_17ck49 = 0 time = 250
.meas tran vdout0_17ck49 FIND v(dout0_17) AT=250.025n

* CHECK dout0_18 Vdout0_18ck49 = 0 time = 250
.meas tran vdout0_18ck49 FIND v(dout0_18) AT=250.025n

* CHECK dout0_19 Vdout0_19ck49 = 0 time = 250
.meas tran vdout0_19ck49 FIND v(dout0_19) AT=250.025n

* CHECK dout0_20 Vdout0_20ck49 = 1.1 time = 250
.meas tran vdout0_20ck49 FIND v(dout0_20) AT=250.025n

* CHECK dout0_21 Vdout0_21ck49 = 0 time = 250
.meas tran vdout0_21ck49 FIND v(dout0_21) AT=250.025n

* CHECK dout0_22 Vdout0_22ck49 = 0 time = 250
.meas tran vdout0_22ck49 FIND v(dout0_22) AT=250.025n

* CHECK dout0_23 Vdout0_23ck49 = 1.1 time = 250
.meas tran vdout0_23ck49 FIND v(dout0_23) AT=250.025n

* CHECK dout0_24 Vdout0_24ck49 = 0 time = 250
.meas tran vdout0_24ck49 FIND v(dout0_24) AT=250.025n

* CHECK dout0_25 Vdout0_25ck49 = 0 time = 250
.meas tran vdout0_25ck49 FIND v(dout0_25) AT=250.025n

* CHECK dout0_26 Vdout0_26ck49 = 1.1 time = 250
.meas tran vdout0_26ck49 FIND v(dout0_26) AT=250.025n

* CHECK dout0_27 Vdout0_27ck49 = 1.1 time = 250
.meas tran vdout0_27ck49 FIND v(dout0_27) AT=250.025n

* CHECK dout0_28 Vdout0_28ck49 = 1.1 time = 250
.meas tran vdout0_28ck49 FIND v(dout0_28) AT=250.025n

* CHECK dout0_29 Vdout0_29ck49 = 1.1 time = 250
.meas tran vdout0_29ck49 FIND v(dout0_29) AT=250.025n

* CHECK dout0_30 Vdout0_30ck49 = 1.1 time = 250
.meas tran vdout0_30ck49 FIND v(dout0_30) AT=250.025n

* CHECK dout0_31 Vdout0_31ck49 = 0 time = 250
.meas tran vdout0_31ck49 FIND v(dout0_31) AT=250.025n

* CHECK dout0_0 Vdout0_0ck52 = 0 time = 265
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=265.025n

* CHECK dout0_1 Vdout0_1ck52 = 0 time = 265
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=265.025n

* CHECK dout0_2 Vdout0_2ck52 = 1.1 time = 265
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=265.025n

* CHECK dout0_3 Vdout0_3ck52 = 1.1 time = 265
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=265.025n

* CHECK dout0_4 Vdout0_4ck52 = 0 time = 265
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=265.025n

* CHECK dout0_5 Vdout0_5ck52 = 0 time = 265
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=265.025n

* CHECK dout0_6 Vdout0_6ck52 = 1.1 time = 265
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=265.025n

* CHECK dout0_7 Vdout0_7ck52 = 0 time = 265
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=265.025n

* CHECK dout0_8 Vdout0_8ck52 = 0 time = 265
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=265.025n

* CHECK dout0_9 Vdout0_9ck52 = 0 time = 265
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=265.025n

* CHECK dout0_10 Vdout0_10ck52 = 0 time = 265
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=265.025n

* CHECK dout0_11 Vdout0_11ck52 = 0 time = 265
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=265.025n

* CHECK dout0_12 Vdout0_12ck52 = 0 time = 265
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=265.025n

* CHECK dout0_13 Vdout0_13ck52 = 1.1 time = 265
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=265.025n

* CHECK dout0_14 Vdout0_14ck52 = 0 time = 265
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=265.025n

* CHECK dout0_15 Vdout0_15ck52 = 0 time = 265
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=265.025n

* CHECK dout0_16 Vdout0_16ck52 = 0 time = 265
.meas tran vdout0_16ck52 FIND v(dout0_16) AT=265.025n

* CHECK dout0_17 Vdout0_17ck52 = 0 time = 265
.meas tran vdout0_17ck52 FIND v(dout0_17) AT=265.025n

* CHECK dout0_18 Vdout0_18ck52 = 0 time = 265
.meas tran vdout0_18ck52 FIND v(dout0_18) AT=265.025n

* CHECK dout0_19 Vdout0_19ck52 = 0 time = 265
.meas tran vdout0_19ck52 FIND v(dout0_19) AT=265.025n

* CHECK dout0_20 Vdout0_20ck52 = 0 time = 265
.meas tran vdout0_20ck52 FIND v(dout0_20) AT=265.025n

* CHECK dout0_21 Vdout0_21ck52 = 1.1 time = 265
.meas tran vdout0_21ck52 FIND v(dout0_21) AT=265.025n

* CHECK dout0_22 Vdout0_22ck52 = 1.1 time = 265
.meas tran vdout0_22ck52 FIND v(dout0_22) AT=265.025n

* CHECK dout0_23 Vdout0_23ck52 = 1.1 time = 265
.meas tran vdout0_23ck52 FIND v(dout0_23) AT=265.025n

* CHECK dout0_24 Vdout0_24ck52 = 0 time = 265
.meas tran vdout0_24ck52 FIND v(dout0_24) AT=265.025n

* CHECK dout0_25 Vdout0_25ck52 = 0 time = 265
.meas tran vdout0_25ck52 FIND v(dout0_25) AT=265.025n

* CHECK dout0_26 Vdout0_26ck52 = 0 time = 265
.meas tran vdout0_26ck52 FIND v(dout0_26) AT=265.025n

* CHECK dout0_27 Vdout0_27ck52 = 0 time = 265
.meas tran vdout0_27ck52 FIND v(dout0_27) AT=265.025n

* CHECK dout0_28 Vdout0_28ck52 = 1.1 time = 265
.meas tran vdout0_28ck52 FIND v(dout0_28) AT=265.025n

* CHECK dout0_29 Vdout0_29ck52 = 1.1 time = 265
.meas tran vdout0_29ck52 FIND v(dout0_29) AT=265.025n

* CHECK dout0_30 Vdout0_30ck52 = 1.1 time = 265
.meas tran vdout0_30ck52 FIND v(dout0_30) AT=265.025n

* CHECK dout0_31 Vdout0_31ck52 = 1.1 time = 265
.meas tran vdout0_31ck52 FIND v(dout0_31) AT=265.025n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 270
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=270.025n

* CHECK dout0_1 Vdout0_1ck53 = 1.1 time = 270
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=270.025n

* CHECK dout0_2 Vdout0_2ck53 = 1.1 time = 270
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=270.025n

* CHECK dout0_3 Vdout0_3ck53 = 0 time = 270
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=270.025n

* CHECK dout0_4 Vdout0_4ck53 = 1.1 time = 270
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=270.025n

* CHECK dout0_5 Vdout0_5ck53 = 0 time = 270
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=270.025n

* CHECK dout0_6 Vdout0_6ck53 = 0 time = 270
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=270.025n

* CHECK dout0_7 Vdout0_7ck53 = 0 time = 270
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=270.025n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 270
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=270.025n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 270
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=270.025n

* CHECK dout0_10 Vdout0_10ck53 = 0 time = 270
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=270.025n

* CHECK dout0_11 Vdout0_11ck53 = 0 time = 270
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=270.025n

* CHECK dout0_12 Vdout0_12ck53 = 0 time = 270
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=270.025n

* CHECK dout0_13 Vdout0_13ck53 = 1.1 time = 270
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=270.025n

* CHECK dout0_14 Vdout0_14ck53 = 0 time = 270
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=270.025n

* CHECK dout0_15 Vdout0_15ck53 = 0 time = 270
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=270.025n

* CHECK dout0_16 Vdout0_16ck53 = 1.1 time = 270
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=270.025n

* CHECK dout0_17 Vdout0_17ck53 = 1.1 time = 270
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=270.025n

* CHECK dout0_18 Vdout0_18ck53 = 0 time = 270
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=270.025n

* CHECK dout0_19 Vdout0_19ck53 = 0 time = 270
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=270.025n

* CHECK dout0_20 Vdout0_20ck53 = 1.1 time = 270
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=270.025n

* CHECK dout0_21 Vdout0_21ck53 = 1.1 time = 270
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=270.025n

* CHECK dout0_22 Vdout0_22ck53 = 0 time = 270
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=270.025n

* CHECK dout0_23 Vdout0_23ck53 = 1.1 time = 270
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=270.025n

* CHECK dout0_24 Vdout0_24ck53 = 0 time = 270
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=270.025n

* CHECK dout0_25 Vdout0_25ck53 = 1.1 time = 270
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=270.025n

* CHECK dout0_26 Vdout0_26ck53 = 0 time = 270
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=270.025n

* CHECK dout0_27 Vdout0_27ck53 = 0 time = 270
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=270.025n

* CHECK dout0_28 Vdout0_28ck53 = 0 time = 270
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=270.025n

* CHECK dout0_29 Vdout0_29ck53 = 0 time = 270
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=270.025n

* CHECK dout0_30 Vdout0_30ck53 = 0 time = 270
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=270.025n

* CHECK dout0_31 Vdout0_31ck53 = 0 time = 270
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=270.025n

* CHECK dout0_0 Vdout0_0ck55 = 0 time = 280
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=280.025n

* CHECK dout0_1 Vdout0_1ck55 = 0 time = 280
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=280.025n

* CHECK dout0_2 Vdout0_2ck55 = 1.1 time = 280
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=280.025n

* CHECK dout0_3 Vdout0_3ck55 = 1.1 time = 280
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=280.025n

* CHECK dout0_4 Vdout0_4ck55 = 0 time = 280
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=280.025n

* CHECK dout0_5 Vdout0_5ck55 = 0 time = 280
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=280.025n

* CHECK dout0_6 Vdout0_6ck55 = 1.1 time = 280
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=280.025n

* CHECK dout0_7 Vdout0_7ck55 = 0 time = 280
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=280.025n

* CHECK dout0_8 Vdout0_8ck55 = 0 time = 280
.meas tran vdout0_8ck55 FIND v(dout0_8) AT=280.025n

* CHECK dout0_9 Vdout0_9ck55 = 0 time = 280
.meas tran vdout0_9ck55 FIND v(dout0_9) AT=280.025n

* CHECK dout0_10 Vdout0_10ck55 = 0 time = 280
.meas tran vdout0_10ck55 FIND v(dout0_10) AT=280.025n

* CHECK dout0_11 Vdout0_11ck55 = 0 time = 280
.meas tran vdout0_11ck55 FIND v(dout0_11) AT=280.025n

* CHECK dout0_12 Vdout0_12ck55 = 0 time = 280
.meas tran vdout0_12ck55 FIND v(dout0_12) AT=280.025n

* CHECK dout0_13 Vdout0_13ck55 = 1.1 time = 280
.meas tran vdout0_13ck55 FIND v(dout0_13) AT=280.025n

* CHECK dout0_14 Vdout0_14ck55 = 0 time = 280
.meas tran vdout0_14ck55 FIND v(dout0_14) AT=280.025n

* CHECK dout0_15 Vdout0_15ck55 = 0 time = 280
.meas tran vdout0_15ck55 FIND v(dout0_15) AT=280.025n

* CHECK dout0_16 Vdout0_16ck55 = 0 time = 280
.meas tran vdout0_16ck55 FIND v(dout0_16) AT=280.025n

* CHECK dout0_17 Vdout0_17ck55 = 0 time = 280
.meas tran vdout0_17ck55 FIND v(dout0_17) AT=280.025n

* CHECK dout0_18 Vdout0_18ck55 = 0 time = 280
.meas tran vdout0_18ck55 FIND v(dout0_18) AT=280.025n

* CHECK dout0_19 Vdout0_19ck55 = 0 time = 280
.meas tran vdout0_19ck55 FIND v(dout0_19) AT=280.025n

* CHECK dout0_20 Vdout0_20ck55 = 0 time = 280
.meas tran vdout0_20ck55 FIND v(dout0_20) AT=280.025n

* CHECK dout0_21 Vdout0_21ck55 = 1.1 time = 280
.meas tran vdout0_21ck55 FIND v(dout0_21) AT=280.025n

* CHECK dout0_22 Vdout0_22ck55 = 1.1 time = 280
.meas tran vdout0_22ck55 FIND v(dout0_22) AT=280.025n

* CHECK dout0_23 Vdout0_23ck55 = 1.1 time = 280
.meas tran vdout0_23ck55 FIND v(dout0_23) AT=280.025n

* CHECK dout0_24 Vdout0_24ck55 = 0 time = 280
.meas tran vdout0_24ck55 FIND v(dout0_24) AT=280.025n

* CHECK dout0_25 Vdout0_25ck55 = 0 time = 280
.meas tran vdout0_25ck55 FIND v(dout0_25) AT=280.025n

* CHECK dout0_26 Vdout0_26ck55 = 0 time = 280
.meas tran vdout0_26ck55 FIND v(dout0_26) AT=280.025n

* CHECK dout0_27 Vdout0_27ck55 = 0 time = 280
.meas tran vdout0_27ck55 FIND v(dout0_27) AT=280.025n

* CHECK dout0_28 Vdout0_28ck55 = 1.1 time = 280
.meas tran vdout0_28ck55 FIND v(dout0_28) AT=280.025n

* CHECK dout0_29 Vdout0_29ck55 = 1.1 time = 280
.meas tran vdout0_29ck55 FIND v(dout0_29) AT=280.025n

* CHECK dout0_30 Vdout0_30ck55 = 1.1 time = 280
.meas tran vdout0_30ck55 FIND v(dout0_30) AT=280.025n

* CHECK dout0_31 Vdout0_31ck55 = 1.1 time = 280
.meas tran vdout0_31ck55 FIND v(dout0_31) AT=280.025n

* CHECK dout0_0 Vdout0_0ck56 = 0 time = 285
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=285.025n

* CHECK dout0_1 Vdout0_1ck56 = 0 time = 285
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=285.025n

* CHECK dout0_2 Vdout0_2ck56 = 0 time = 285
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=285.025n

* CHECK dout0_3 Vdout0_3ck56 = 0 time = 285
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=285.025n

* CHECK dout0_4 Vdout0_4ck56 = 0 time = 285
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=285.025n

* CHECK dout0_5 Vdout0_5ck56 = 0 time = 285
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=285.025n

* CHECK dout0_6 Vdout0_6ck56 = 1.1 time = 285
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=285.025n

* CHECK dout0_7 Vdout0_7ck56 = 0 time = 285
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=285.025n

* CHECK dout0_8 Vdout0_8ck56 = 0 time = 285
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=285.025n

* CHECK dout0_9 Vdout0_9ck56 = 0 time = 285
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=285.025n

* CHECK dout0_10 Vdout0_10ck56 = 1.1 time = 285
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=285.025n

* CHECK dout0_11 Vdout0_11ck56 = 1.1 time = 285
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=285.025n

* CHECK dout0_12 Vdout0_12ck56 = 0 time = 285
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=285.025n

* CHECK dout0_13 Vdout0_13ck56 = 0 time = 285
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=285.025n

* CHECK dout0_14 Vdout0_14ck56 = 0 time = 285
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=285.025n

* CHECK dout0_15 Vdout0_15ck56 = 0 time = 285
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=285.025n

* CHECK dout0_16 Vdout0_16ck56 = 1.1 time = 285
.meas tran vdout0_16ck56 FIND v(dout0_16) AT=285.025n

* CHECK dout0_17 Vdout0_17ck56 = 1.1 time = 285
.meas tran vdout0_17ck56 FIND v(dout0_17) AT=285.025n

* CHECK dout0_18 Vdout0_18ck56 = 1.1 time = 285
.meas tran vdout0_18ck56 FIND v(dout0_18) AT=285.025n

* CHECK dout0_19 Vdout0_19ck56 = 0 time = 285
.meas tran vdout0_19ck56 FIND v(dout0_19) AT=285.025n

* CHECK dout0_20 Vdout0_20ck56 = 0 time = 285
.meas tran vdout0_20ck56 FIND v(dout0_20) AT=285.025n

* CHECK dout0_21 Vdout0_21ck56 = 0 time = 285
.meas tran vdout0_21ck56 FIND v(dout0_21) AT=285.025n

* CHECK dout0_22 Vdout0_22ck56 = 1.1 time = 285
.meas tran vdout0_22ck56 FIND v(dout0_22) AT=285.025n

* CHECK dout0_23 Vdout0_23ck56 = 0 time = 285
.meas tran vdout0_23ck56 FIND v(dout0_23) AT=285.025n

* CHECK dout0_24 Vdout0_24ck56 = 0 time = 285
.meas tran vdout0_24ck56 FIND v(dout0_24) AT=285.025n

* CHECK dout0_25 Vdout0_25ck56 = 0 time = 285
.meas tran vdout0_25ck56 FIND v(dout0_25) AT=285.025n

* CHECK dout0_26 Vdout0_26ck56 = 0 time = 285
.meas tran vdout0_26ck56 FIND v(dout0_26) AT=285.025n

* CHECK dout0_27 Vdout0_27ck56 = 0 time = 285
.meas tran vdout0_27ck56 FIND v(dout0_27) AT=285.025n

* CHECK dout0_28 Vdout0_28ck56 = 0 time = 285
.meas tran vdout0_28ck56 FIND v(dout0_28) AT=285.025n

* CHECK dout0_29 Vdout0_29ck56 = 0 time = 285
.meas tran vdout0_29ck56 FIND v(dout0_29) AT=285.025n

* CHECK dout0_30 Vdout0_30ck56 = 1.1 time = 285
.meas tran vdout0_30ck56 FIND v(dout0_30) AT=285.025n

* CHECK dout0_31 Vdout0_31ck56 = 1.1 time = 285
.meas tran vdout0_31ck56 FIND v(dout0_31) AT=285.025n

* CHECK dout0_0 Vdout0_0ck58 = 0 time = 295
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=295.025n

* CHECK dout0_1 Vdout0_1ck58 = 1.1 time = 295
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=295.025n

* CHECK dout0_2 Vdout0_2ck58 = 1.1 time = 295
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=295.025n

* CHECK dout0_3 Vdout0_3ck58 = 0 time = 295
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=295.025n

* CHECK dout0_4 Vdout0_4ck58 = 1.1 time = 295
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=295.025n

* CHECK dout0_5 Vdout0_5ck58 = 0 time = 295
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=295.025n

* CHECK dout0_6 Vdout0_6ck58 = 0 time = 295
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=295.025n

* CHECK dout0_7 Vdout0_7ck58 = 0 time = 295
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=295.025n

* CHECK dout0_8 Vdout0_8ck58 = 0 time = 295
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=295.025n

* CHECK dout0_9 Vdout0_9ck58 = 0 time = 295
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=295.025n

* CHECK dout0_10 Vdout0_10ck58 = 0 time = 295
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=295.025n

* CHECK dout0_11 Vdout0_11ck58 = 0 time = 295
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=295.025n

* CHECK dout0_12 Vdout0_12ck58 = 0 time = 295
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=295.025n

* CHECK dout0_13 Vdout0_13ck58 = 1.1 time = 295
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=295.025n

* CHECK dout0_14 Vdout0_14ck58 = 0 time = 295
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=295.025n

* CHECK dout0_15 Vdout0_15ck58 = 0 time = 295
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=295.025n

* CHECK dout0_16 Vdout0_16ck58 = 1.1 time = 295
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=295.025n

* CHECK dout0_17 Vdout0_17ck58 = 1.1 time = 295
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=295.025n

* CHECK dout0_18 Vdout0_18ck58 = 0 time = 295
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=295.025n

* CHECK dout0_19 Vdout0_19ck58 = 0 time = 295
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=295.025n

* CHECK dout0_20 Vdout0_20ck58 = 1.1 time = 295
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=295.025n

* CHECK dout0_21 Vdout0_21ck58 = 1.1 time = 295
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=295.025n

* CHECK dout0_22 Vdout0_22ck58 = 0 time = 295
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=295.025n

* CHECK dout0_23 Vdout0_23ck58 = 1.1 time = 295
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=295.025n

* CHECK dout0_24 Vdout0_24ck58 = 0 time = 295
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=295.025n

* CHECK dout0_25 Vdout0_25ck58 = 1.1 time = 295
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=295.025n

* CHECK dout0_26 Vdout0_26ck58 = 0 time = 295
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=295.025n

* CHECK dout0_27 Vdout0_27ck58 = 0 time = 295
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=295.025n

* CHECK dout0_28 Vdout0_28ck58 = 0 time = 295
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=295.025n

* CHECK dout0_29 Vdout0_29ck58 = 0 time = 295
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=295.025n

* CHECK dout0_30 Vdout0_30ck58 = 0 time = 295
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=295.025n

* CHECK dout0_31 Vdout0_31ck58 = 0 time = 295
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=295.025n

* CHECK dout0_0 Vdout0_0ck60 = 0 time = 305
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=305.025n

* CHECK dout0_1 Vdout0_1ck60 = 1.1 time = 305
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=305.025n

* CHECK dout0_2 Vdout0_2ck60 = 1.1 time = 305
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=305.025n

* CHECK dout0_3 Vdout0_3ck60 = 0 time = 305
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=305.025n

* CHECK dout0_4 Vdout0_4ck60 = 0 time = 305
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=305.025n

* CHECK dout0_5 Vdout0_5ck60 = 0 time = 305
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=305.025n

* CHECK dout0_6 Vdout0_6ck60 = 0 time = 305
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=305.025n

* CHECK dout0_7 Vdout0_7ck60 = 1.1 time = 305
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=305.025n

* CHECK dout0_8 Vdout0_8ck60 = 0 time = 305
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=305.025n

* CHECK dout0_9 Vdout0_9ck60 = 1.1 time = 305
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=305.025n

* CHECK dout0_10 Vdout0_10ck60 = 1.1 time = 305
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=305.025n

* CHECK dout0_11 Vdout0_11ck60 = 1.1 time = 305
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=305.025n

* CHECK dout0_12 Vdout0_12ck60 = 1.1 time = 305
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=305.025n

* CHECK dout0_13 Vdout0_13ck60 = 1.1 time = 305
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=305.025n

* CHECK dout0_14 Vdout0_14ck60 = 0 time = 305
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=305.025n

* CHECK dout0_15 Vdout0_15ck60 = 0 time = 305
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=305.025n

* CHECK dout0_16 Vdout0_16ck60 = 0 time = 305
.meas tran vdout0_16ck60 FIND v(dout0_16) AT=305.025n

* CHECK dout0_17 Vdout0_17ck60 = 0 time = 305
.meas tran vdout0_17ck60 FIND v(dout0_17) AT=305.025n

* CHECK dout0_18 Vdout0_18ck60 = 0 time = 305
.meas tran vdout0_18ck60 FIND v(dout0_18) AT=305.025n

* CHECK dout0_19 Vdout0_19ck60 = 0 time = 305
.meas tran vdout0_19ck60 FIND v(dout0_19) AT=305.025n

* CHECK dout0_20 Vdout0_20ck60 = 1.1 time = 305
.meas tran vdout0_20ck60 FIND v(dout0_20) AT=305.025n

* CHECK dout0_21 Vdout0_21ck60 = 0 time = 305
.meas tran vdout0_21ck60 FIND v(dout0_21) AT=305.025n

* CHECK dout0_22 Vdout0_22ck60 = 1.1 time = 305
.meas tran vdout0_22ck60 FIND v(dout0_22) AT=305.025n

* CHECK dout0_23 Vdout0_23ck60 = 0 time = 305
.meas tran vdout0_23ck60 FIND v(dout0_23) AT=305.025n

* CHECK dout0_24 Vdout0_24ck60 = 0 time = 305
.meas tran vdout0_24ck60 FIND v(dout0_24) AT=305.025n

* CHECK dout0_25 Vdout0_25ck60 = 0 time = 305
.meas tran vdout0_25ck60 FIND v(dout0_25) AT=305.025n

* CHECK dout0_26 Vdout0_26ck60 = 0 time = 305
.meas tran vdout0_26ck60 FIND v(dout0_26) AT=305.025n

* CHECK dout0_27 Vdout0_27ck60 = 1.1 time = 305
.meas tran vdout0_27ck60 FIND v(dout0_27) AT=305.025n

* CHECK dout0_28 Vdout0_28ck60 = 0 time = 305
.meas tran vdout0_28ck60 FIND v(dout0_28) AT=305.025n

* CHECK dout0_29 Vdout0_29ck60 = 0 time = 305
.meas tran vdout0_29ck60 FIND v(dout0_29) AT=305.025n

* CHECK dout0_30 Vdout0_30ck60 = 0 time = 305
.meas tran vdout0_30ck60 FIND v(dout0_30) AT=305.025n

* CHECK dout0_31 Vdout0_31ck60 = 0 time = 305
.meas tran vdout0_31ck60 FIND v(dout0_31) AT=305.025n

* CHECK dout0_0 Vdout0_0ck62 = 0 time = 315
.meas tran vdout0_0ck62 FIND v(dout0_0) AT=315.025n

* CHECK dout0_1 Vdout0_1ck62 = 0 time = 315
.meas tran vdout0_1ck62 FIND v(dout0_1) AT=315.025n

* CHECK dout0_2 Vdout0_2ck62 = 1.1 time = 315
.meas tran vdout0_2ck62 FIND v(dout0_2) AT=315.025n

* CHECK dout0_3 Vdout0_3ck62 = 1.1 time = 315
.meas tran vdout0_3ck62 FIND v(dout0_3) AT=315.025n

* CHECK dout0_4 Vdout0_4ck62 = 0 time = 315
.meas tran vdout0_4ck62 FIND v(dout0_4) AT=315.025n

* CHECK dout0_5 Vdout0_5ck62 = 0 time = 315
.meas tran vdout0_5ck62 FIND v(dout0_5) AT=315.025n

* CHECK dout0_6 Vdout0_6ck62 = 1.1 time = 315
.meas tran vdout0_6ck62 FIND v(dout0_6) AT=315.025n

* CHECK dout0_7 Vdout0_7ck62 = 0 time = 315
.meas tran vdout0_7ck62 FIND v(dout0_7) AT=315.025n

* CHECK dout0_8 Vdout0_8ck62 = 0 time = 315
.meas tran vdout0_8ck62 FIND v(dout0_8) AT=315.025n

* CHECK dout0_9 Vdout0_9ck62 = 0 time = 315
.meas tran vdout0_9ck62 FIND v(dout0_9) AT=315.025n

* CHECK dout0_10 Vdout0_10ck62 = 0 time = 315
.meas tran vdout0_10ck62 FIND v(dout0_10) AT=315.025n

* CHECK dout0_11 Vdout0_11ck62 = 0 time = 315
.meas tran vdout0_11ck62 FIND v(dout0_11) AT=315.025n

* CHECK dout0_12 Vdout0_12ck62 = 0 time = 315
.meas tran vdout0_12ck62 FIND v(dout0_12) AT=315.025n

* CHECK dout0_13 Vdout0_13ck62 = 1.1 time = 315
.meas tran vdout0_13ck62 FIND v(dout0_13) AT=315.025n

* CHECK dout0_14 Vdout0_14ck62 = 0 time = 315
.meas tran vdout0_14ck62 FIND v(dout0_14) AT=315.025n

* CHECK dout0_15 Vdout0_15ck62 = 0 time = 315
.meas tran vdout0_15ck62 FIND v(dout0_15) AT=315.025n

* CHECK dout0_16 Vdout0_16ck62 = 0 time = 315
.meas tran vdout0_16ck62 FIND v(dout0_16) AT=315.025n

* CHECK dout0_17 Vdout0_17ck62 = 0 time = 315
.meas tran vdout0_17ck62 FIND v(dout0_17) AT=315.025n

* CHECK dout0_18 Vdout0_18ck62 = 0 time = 315
.meas tran vdout0_18ck62 FIND v(dout0_18) AT=315.025n

* CHECK dout0_19 Vdout0_19ck62 = 0 time = 315
.meas tran vdout0_19ck62 FIND v(dout0_19) AT=315.025n

* CHECK dout0_20 Vdout0_20ck62 = 0 time = 315
.meas tran vdout0_20ck62 FIND v(dout0_20) AT=315.025n

* CHECK dout0_21 Vdout0_21ck62 = 1.1 time = 315
.meas tran vdout0_21ck62 FIND v(dout0_21) AT=315.025n

* CHECK dout0_22 Vdout0_22ck62 = 1.1 time = 315
.meas tran vdout0_22ck62 FIND v(dout0_22) AT=315.025n

* CHECK dout0_23 Vdout0_23ck62 = 1.1 time = 315
.meas tran vdout0_23ck62 FIND v(dout0_23) AT=315.025n

* CHECK dout0_24 Vdout0_24ck62 = 0 time = 315
.meas tran vdout0_24ck62 FIND v(dout0_24) AT=315.025n

* CHECK dout0_25 Vdout0_25ck62 = 0 time = 315
.meas tran vdout0_25ck62 FIND v(dout0_25) AT=315.025n

* CHECK dout0_26 Vdout0_26ck62 = 0 time = 315
.meas tran vdout0_26ck62 FIND v(dout0_26) AT=315.025n

* CHECK dout0_27 Vdout0_27ck62 = 0 time = 315
.meas tran vdout0_27ck62 FIND v(dout0_27) AT=315.025n

* CHECK dout0_28 Vdout0_28ck62 = 1.1 time = 315
.meas tran vdout0_28ck62 FIND v(dout0_28) AT=315.025n

* CHECK dout0_29 Vdout0_29ck62 = 1.1 time = 315
.meas tran vdout0_29ck62 FIND v(dout0_29) AT=315.025n

* CHECK dout0_30 Vdout0_30ck62 = 1.1 time = 315
.meas tran vdout0_30ck62 FIND v(dout0_30) AT=315.025n

* CHECK dout0_31 Vdout0_31ck62 = 1.1 time = 315
.meas tran vdout0_31ck62 FIND v(dout0_31) AT=315.025n

* CHECK dout0_0 Vdout0_0ck64 = 0 time = 325
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=325.025n

* CHECK dout0_1 Vdout0_1ck64 = 0 time = 325
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=325.025n

* CHECK dout0_2 Vdout0_2ck64 = 0 time = 325
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=325.025n

* CHECK dout0_3 Vdout0_3ck64 = 1.1 time = 325
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=325.025n

* CHECK dout0_4 Vdout0_4ck64 = 0 time = 325
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=325.025n

* CHECK dout0_5 Vdout0_5ck64 = 1.1 time = 325
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=325.025n

* CHECK dout0_6 Vdout0_6ck64 = 0 time = 325
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=325.025n

* CHECK dout0_7 Vdout0_7ck64 = 0 time = 325
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=325.025n

* CHECK dout0_8 Vdout0_8ck64 = 1.1 time = 325
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=325.025n

* CHECK dout0_9 Vdout0_9ck64 = 0 time = 325
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=325.025n

* CHECK dout0_10 Vdout0_10ck64 = 0 time = 325
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=325.025n

* CHECK dout0_11 Vdout0_11ck64 = 0 time = 325
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=325.025n

* CHECK dout0_12 Vdout0_12ck64 = 0 time = 325
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=325.025n

* CHECK dout0_13 Vdout0_13ck64 = 1.1 time = 325
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=325.025n

* CHECK dout0_14 Vdout0_14ck64 = 1.1 time = 325
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=325.025n

* CHECK dout0_15 Vdout0_15ck64 = 0 time = 325
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=325.025n

* CHECK dout0_16 Vdout0_16ck64 = 0 time = 325
.meas tran vdout0_16ck64 FIND v(dout0_16) AT=325.025n

* CHECK dout0_17 Vdout0_17ck64 = 1.1 time = 325
.meas tran vdout0_17ck64 FIND v(dout0_17) AT=325.025n

* CHECK dout0_18 Vdout0_18ck64 = 0 time = 325
.meas tran vdout0_18ck64 FIND v(dout0_18) AT=325.025n

* CHECK dout0_19 Vdout0_19ck64 = 0 time = 325
.meas tran vdout0_19ck64 FIND v(dout0_19) AT=325.025n

* CHECK dout0_20 Vdout0_20ck64 = 0 time = 325
.meas tran vdout0_20ck64 FIND v(dout0_20) AT=325.025n

* CHECK dout0_21 Vdout0_21ck64 = 0 time = 325
.meas tran vdout0_21ck64 FIND v(dout0_21) AT=325.025n

* CHECK dout0_22 Vdout0_22ck64 = 0 time = 325
.meas tran vdout0_22ck64 FIND v(dout0_22) AT=325.025n

* CHECK dout0_23 Vdout0_23ck64 = 0 time = 325
.meas tran vdout0_23ck64 FIND v(dout0_23) AT=325.025n

* CHECK dout0_24 Vdout0_24ck64 = 1.1 time = 325
.meas tran vdout0_24ck64 FIND v(dout0_24) AT=325.025n

* CHECK dout0_25 Vdout0_25ck64 = 0 time = 325
.meas tran vdout0_25ck64 FIND v(dout0_25) AT=325.025n

* CHECK dout0_26 Vdout0_26ck64 = 0 time = 325
.meas tran vdout0_26ck64 FIND v(dout0_26) AT=325.025n

* CHECK dout0_27 Vdout0_27ck64 = 1.1 time = 325
.meas tran vdout0_27ck64 FIND v(dout0_27) AT=325.025n

* CHECK dout0_28 Vdout0_28ck64 = 1.1 time = 325
.meas tran vdout0_28ck64 FIND v(dout0_28) AT=325.025n

* CHECK dout0_29 Vdout0_29ck64 = 1.1 time = 325
.meas tran vdout0_29ck64 FIND v(dout0_29) AT=325.025n

* CHECK dout0_30 Vdout0_30ck64 = 1.1 time = 325
.meas tran vdout0_30ck64 FIND v(dout0_30) AT=325.025n

* CHECK dout0_31 Vdout0_31ck64 = 0 time = 325
.meas tran vdout0_31ck64 FIND v(dout0_31) AT=325.025n

* CHECK dout0_0 Vdout0_0ck67 = 0 time = 340
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=340.025n

* CHECK dout0_1 Vdout0_1ck67 = 0 time = 340
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=340.025n

* CHECK dout0_2 Vdout0_2ck67 = 0 time = 340
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=340.025n

* CHECK dout0_3 Vdout0_3ck67 = 1.1 time = 340
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=340.025n

* CHECK dout0_4 Vdout0_4ck67 = 0 time = 340
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=340.025n

* CHECK dout0_5 Vdout0_5ck67 = 1.1 time = 340
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=340.025n

* CHECK dout0_6 Vdout0_6ck67 = 0 time = 340
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=340.025n

* CHECK dout0_7 Vdout0_7ck67 = 0 time = 340
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=340.025n

* CHECK dout0_8 Vdout0_8ck67 = 1.1 time = 340
.meas tran vdout0_8ck67 FIND v(dout0_8) AT=340.025n

* CHECK dout0_9 Vdout0_9ck67 = 0 time = 340
.meas tran vdout0_9ck67 FIND v(dout0_9) AT=340.025n

* CHECK dout0_10 Vdout0_10ck67 = 0 time = 340
.meas tran vdout0_10ck67 FIND v(dout0_10) AT=340.025n

* CHECK dout0_11 Vdout0_11ck67 = 0 time = 340
.meas tran vdout0_11ck67 FIND v(dout0_11) AT=340.025n

* CHECK dout0_12 Vdout0_12ck67 = 0 time = 340
.meas tran vdout0_12ck67 FIND v(dout0_12) AT=340.025n

* CHECK dout0_13 Vdout0_13ck67 = 1.1 time = 340
.meas tran vdout0_13ck67 FIND v(dout0_13) AT=340.025n

* CHECK dout0_14 Vdout0_14ck67 = 1.1 time = 340
.meas tran vdout0_14ck67 FIND v(dout0_14) AT=340.025n

* CHECK dout0_15 Vdout0_15ck67 = 0 time = 340
.meas tran vdout0_15ck67 FIND v(dout0_15) AT=340.025n

* CHECK dout0_16 Vdout0_16ck67 = 0 time = 340
.meas tran vdout0_16ck67 FIND v(dout0_16) AT=340.025n

* CHECK dout0_17 Vdout0_17ck67 = 1.1 time = 340
.meas tran vdout0_17ck67 FIND v(dout0_17) AT=340.025n

* CHECK dout0_18 Vdout0_18ck67 = 0 time = 340
.meas tran vdout0_18ck67 FIND v(dout0_18) AT=340.025n

* CHECK dout0_19 Vdout0_19ck67 = 0 time = 340
.meas tran vdout0_19ck67 FIND v(dout0_19) AT=340.025n

* CHECK dout0_20 Vdout0_20ck67 = 0 time = 340
.meas tran vdout0_20ck67 FIND v(dout0_20) AT=340.025n

* CHECK dout0_21 Vdout0_21ck67 = 0 time = 340
.meas tran vdout0_21ck67 FIND v(dout0_21) AT=340.025n

* CHECK dout0_22 Vdout0_22ck67 = 0 time = 340
.meas tran vdout0_22ck67 FIND v(dout0_22) AT=340.025n

* CHECK dout0_23 Vdout0_23ck67 = 0 time = 340
.meas tran vdout0_23ck67 FIND v(dout0_23) AT=340.025n

* CHECK dout0_24 Vdout0_24ck67 = 1.1 time = 340
.meas tran vdout0_24ck67 FIND v(dout0_24) AT=340.025n

* CHECK dout0_25 Vdout0_25ck67 = 0 time = 340
.meas tran vdout0_25ck67 FIND v(dout0_25) AT=340.025n

* CHECK dout0_26 Vdout0_26ck67 = 0 time = 340
.meas tran vdout0_26ck67 FIND v(dout0_26) AT=340.025n

* CHECK dout0_27 Vdout0_27ck67 = 1.1 time = 340
.meas tran vdout0_27ck67 FIND v(dout0_27) AT=340.025n

* CHECK dout0_28 Vdout0_28ck67 = 1.1 time = 340
.meas tran vdout0_28ck67 FIND v(dout0_28) AT=340.025n

* CHECK dout0_29 Vdout0_29ck67 = 1.1 time = 340
.meas tran vdout0_29ck67 FIND v(dout0_29) AT=340.025n

* CHECK dout0_30 Vdout0_30ck67 = 1.1 time = 340
.meas tran vdout0_30ck67 FIND v(dout0_30) AT=340.025n

* CHECK dout0_31 Vdout0_31ck67 = 0 time = 340
.meas tran vdout0_31ck67 FIND v(dout0_31) AT=340.025n

* CHECK dout0_0 Vdout0_0ck68 = 0 time = 345
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=345.025n

* CHECK dout0_1 Vdout0_1ck68 = 1.1 time = 345
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=345.025n

* CHECK dout0_2 Vdout0_2ck68 = 1.1 time = 345
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=345.025n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 345
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=345.025n

* CHECK dout0_4 Vdout0_4ck68 = 1.1 time = 345
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=345.025n

* CHECK dout0_5 Vdout0_5ck68 = 0 time = 345
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=345.025n

* CHECK dout0_6 Vdout0_6ck68 = 0 time = 345
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=345.025n

* CHECK dout0_7 Vdout0_7ck68 = 0 time = 345
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=345.025n

* CHECK dout0_8 Vdout0_8ck68 = 0 time = 345
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=345.025n

* CHECK dout0_9 Vdout0_9ck68 = 0 time = 345
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=345.025n

* CHECK dout0_10 Vdout0_10ck68 = 0 time = 345
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=345.025n

* CHECK dout0_11 Vdout0_11ck68 = 0 time = 345
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=345.025n

* CHECK dout0_12 Vdout0_12ck68 = 0 time = 345
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=345.025n

* CHECK dout0_13 Vdout0_13ck68 = 1.1 time = 345
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=345.025n

* CHECK dout0_14 Vdout0_14ck68 = 0 time = 345
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=345.025n

* CHECK dout0_15 Vdout0_15ck68 = 0 time = 345
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=345.025n

* CHECK dout0_16 Vdout0_16ck68 = 1.1 time = 345
.meas tran vdout0_16ck68 FIND v(dout0_16) AT=345.025n

* CHECK dout0_17 Vdout0_17ck68 = 1.1 time = 345
.meas tran vdout0_17ck68 FIND v(dout0_17) AT=345.025n

* CHECK dout0_18 Vdout0_18ck68 = 0 time = 345
.meas tran vdout0_18ck68 FIND v(dout0_18) AT=345.025n

* CHECK dout0_19 Vdout0_19ck68 = 0 time = 345
.meas tran vdout0_19ck68 FIND v(dout0_19) AT=345.025n

* CHECK dout0_20 Vdout0_20ck68 = 1.1 time = 345
.meas tran vdout0_20ck68 FIND v(dout0_20) AT=345.025n

* CHECK dout0_21 Vdout0_21ck68 = 1.1 time = 345
.meas tran vdout0_21ck68 FIND v(dout0_21) AT=345.025n

* CHECK dout0_22 Vdout0_22ck68 = 0 time = 345
.meas tran vdout0_22ck68 FIND v(dout0_22) AT=345.025n

* CHECK dout0_23 Vdout0_23ck68 = 1.1 time = 345
.meas tran vdout0_23ck68 FIND v(dout0_23) AT=345.025n

* CHECK dout0_24 Vdout0_24ck68 = 0 time = 345
.meas tran vdout0_24ck68 FIND v(dout0_24) AT=345.025n

* CHECK dout0_25 Vdout0_25ck68 = 1.1 time = 345
.meas tran vdout0_25ck68 FIND v(dout0_25) AT=345.025n

* CHECK dout0_26 Vdout0_26ck68 = 0 time = 345
.meas tran vdout0_26ck68 FIND v(dout0_26) AT=345.025n

* CHECK dout0_27 Vdout0_27ck68 = 0 time = 345
.meas tran vdout0_27ck68 FIND v(dout0_27) AT=345.025n

* CHECK dout0_28 Vdout0_28ck68 = 0 time = 345
.meas tran vdout0_28ck68 FIND v(dout0_28) AT=345.025n

* CHECK dout0_29 Vdout0_29ck68 = 0 time = 345
.meas tran vdout0_29ck68 FIND v(dout0_29) AT=345.025n

* CHECK dout0_30 Vdout0_30ck68 = 0 time = 345
.meas tran vdout0_30ck68 FIND v(dout0_30) AT=345.025n

* CHECK dout0_31 Vdout0_31ck68 = 0 time = 345
.meas tran vdout0_31ck68 FIND v(dout0_31) AT=345.025n

* CHECK dout0_0 Vdout0_0ck70 = 0 time = 355
.meas tran vdout0_0ck70 FIND v(dout0_0) AT=355.025n

* CHECK dout0_1 Vdout0_1ck70 = 0 time = 355
.meas tran vdout0_1ck70 FIND v(dout0_1) AT=355.025n

* CHECK dout0_2 Vdout0_2ck70 = 0 time = 355
.meas tran vdout0_2ck70 FIND v(dout0_2) AT=355.025n

* CHECK dout0_3 Vdout0_3ck70 = 0 time = 355
.meas tran vdout0_3ck70 FIND v(dout0_3) AT=355.025n

* CHECK dout0_4 Vdout0_4ck70 = 0 time = 355
.meas tran vdout0_4ck70 FIND v(dout0_4) AT=355.025n

* CHECK dout0_5 Vdout0_5ck70 = 0 time = 355
.meas tran vdout0_5ck70 FIND v(dout0_5) AT=355.025n

* CHECK dout0_6 Vdout0_6ck70 = 1.1 time = 355
.meas tran vdout0_6ck70 FIND v(dout0_6) AT=355.025n

* CHECK dout0_7 Vdout0_7ck70 = 0 time = 355
.meas tran vdout0_7ck70 FIND v(dout0_7) AT=355.025n

* CHECK dout0_8 Vdout0_8ck70 = 0 time = 355
.meas tran vdout0_8ck70 FIND v(dout0_8) AT=355.025n

* CHECK dout0_9 Vdout0_9ck70 = 0 time = 355
.meas tran vdout0_9ck70 FIND v(dout0_9) AT=355.025n

* CHECK dout0_10 Vdout0_10ck70 = 1.1 time = 355
.meas tran vdout0_10ck70 FIND v(dout0_10) AT=355.025n

* CHECK dout0_11 Vdout0_11ck70 = 1.1 time = 355
.meas tran vdout0_11ck70 FIND v(dout0_11) AT=355.025n

* CHECK dout0_12 Vdout0_12ck70 = 0 time = 355
.meas tran vdout0_12ck70 FIND v(dout0_12) AT=355.025n

* CHECK dout0_13 Vdout0_13ck70 = 0 time = 355
.meas tran vdout0_13ck70 FIND v(dout0_13) AT=355.025n

* CHECK dout0_14 Vdout0_14ck70 = 0 time = 355
.meas tran vdout0_14ck70 FIND v(dout0_14) AT=355.025n

* CHECK dout0_15 Vdout0_15ck70 = 0 time = 355
.meas tran vdout0_15ck70 FIND v(dout0_15) AT=355.025n

* CHECK dout0_16 Vdout0_16ck70 = 1.1 time = 355
.meas tran vdout0_16ck70 FIND v(dout0_16) AT=355.025n

* CHECK dout0_17 Vdout0_17ck70 = 1.1 time = 355
.meas tran vdout0_17ck70 FIND v(dout0_17) AT=355.025n

* CHECK dout0_18 Vdout0_18ck70 = 1.1 time = 355
.meas tran vdout0_18ck70 FIND v(dout0_18) AT=355.025n

* CHECK dout0_19 Vdout0_19ck70 = 0 time = 355
.meas tran vdout0_19ck70 FIND v(dout0_19) AT=355.025n

* CHECK dout0_20 Vdout0_20ck70 = 0 time = 355
.meas tran vdout0_20ck70 FIND v(dout0_20) AT=355.025n

* CHECK dout0_21 Vdout0_21ck70 = 0 time = 355
.meas tran vdout0_21ck70 FIND v(dout0_21) AT=355.025n

* CHECK dout0_22 Vdout0_22ck70 = 1.1 time = 355
.meas tran vdout0_22ck70 FIND v(dout0_22) AT=355.025n

* CHECK dout0_23 Vdout0_23ck70 = 0 time = 355
.meas tran vdout0_23ck70 FIND v(dout0_23) AT=355.025n

* CHECK dout0_24 Vdout0_24ck70 = 0 time = 355
.meas tran vdout0_24ck70 FIND v(dout0_24) AT=355.025n

* CHECK dout0_25 Vdout0_25ck70 = 0 time = 355
.meas tran vdout0_25ck70 FIND v(dout0_25) AT=355.025n

* CHECK dout0_26 Vdout0_26ck70 = 0 time = 355
.meas tran vdout0_26ck70 FIND v(dout0_26) AT=355.025n

* CHECK dout0_27 Vdout0_27ck70 = 0 time = 355
.meas tran vdout0_27ck70 FIND v(dout0_27) AT=355.025n

* CHECK dout0_28 Vdout0_28ck70 = 0 time = 355
.meas tran vdout0_28ck70 FIND v(dout0_28) AT=355.025n

* CHECK dout0_29 Vdout0_29ck70 = 0 time = 355
.meas tran vdout0_29ck70 FIND v(dout0_29) AT=355.025n

* CHECK dout0_30 Vdout0_30ck70 = 1.1 time = 355
.meas tran vdout0_30ck70 FIND v(dout0_30) AT=355.025n

* CHECK dout0_31 Vdout0_31ck70 = 1.1 time = 355
.meas tran vdout0_31ck70 FIND v(dout0_31) AT=355.025n

* CHECK dout0_0 Vdout0_0ck72 = 0 time = 365
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=365.025n

* CHECK dout0_1 Vdout0_1ck72 = 1.1 time = 365
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=365.025n

* CHECK dout0_2 Vdout0_2ck72 = 0 time = 365
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=365.025n

* CHECK dout0_3 Vdout0_3ck72 = 0 time = 365
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=365.025n

* CHECK dout0_4 Vdout0_4ck72 = 0 time = 365
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=365.025n

* CHECK dout0_5 Vdout0_5ck72 = 0 time = 365
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=365.025n

* CHECK dout0_6 Vdout0_6ck72 = 1.1 time = 365
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=365.025n

* CHECK dout0_7 Vdout0_7ck72 = 0 time = 365
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=365.025n

* CHECK dout0_8 Vdout0_8ck72 = 1.1 time = 365
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=365.025n

* CHECK dout0_9 Vdout0_9ck72 = 1.1 time = 365
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=365.025n

* CHECK dout0_10 Vdout0_10ck72 = 1.1 time = 365
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=365.025n

* CHECK dout0_11 Vdout0_11ck72 = 0 time = 365
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=365.025n

* CHECK dout0_12 Vdout0_12ck72 = 0 time = 365
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=365.025n

* CHECK dout0_13 Vdout0_13ck72 = 1.1 time = 365
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=365.025n

* CHECK dout0_14 Vdout0_14ck72 = 1.1 time = 365
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=365.025n

* CHECK dout0_15 Vdout0_15ck72 = 1.1 time = 365
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=365.025n

* CHECK dout0_16 Vdout0_16ck72 = 1.1 time = 365
.meas tran vdout0_16ck72 FIND v(dout0_16) AT=365.025n

* CHECK dout0_17 Vdout0_17ck72 = 1.1 time = 365
.meas tran vdout0_17ck72 FIND v(dout0_17) AT=365.025n

* CHECK dout0_18 Vdout0_18ck72 = 0 time = 365
.meas tran vdout0_18ck72 FIND v(dout0_18) AT=365.025n

* CHECK dout0_19 Vdout0_19ck72 = 1.1 time = 365
.meas tran vdout0_19ck72 FIND v(dout0_19) AT=365.025n

* CHECK dout0_20 Vdout0_20ck72 = 1.1 time = 365
.meas tran vdout0_20ck72 FIND v(dout0_20) AT=365.025n

* CHECK dout0_21 Vdout0_21ck72 = 1.1 time = 365
.meas tran vdout0_21ck72 FIND v(dout0_21) AT=365.025n

* CHECK dout0_22 Vdout0_22ck72 = 1.1 time = 365
.meas tran vdout0_22ck72 FIND v(dout0_22) AT=365.025n

* CHECK dout0_23 Vdout0_23ck72 = 0 time = 365
.meas tran vdout0_23ck72 FIND v(dout0_23) AT=365.025n

* CHECK dout0_24 Vdout0_24ck72 = 1.1 time = 365
.meas tran vdout0_24ck72 FIND v(dout0_24) AT=365.025n

* CHECK dout0_25 Vdout0_25ck72 = 0 time = 365
.meas tran vdout0_25ck72 FIND v(dout0_25) AT=365.025n

* CHECK dout0_26 Vdout0_26ck72 = 1.1 time = 365
.meas tran vdout0_26ck72 FIND v(dout0_26) AT=365.025n

* CHECK dout0_27 Vdout0_27ck72 = 0 time = 365
.meas tran vdout0_27ck72 FIND v(dout0_27) AT=365.025n

* CHECK dout0_28 Vdout0_28ck72 = 1.1 time = 365
.meas tran vdout0_28ck72 FIND v(dout0_28) AT=365.025n

* CHECK dout0_29 Vdout0_29ck72 = 1.1 time = 365
.meas tran vdout0_29ck72 FIND v(dout0_29) AT=365.025n

* CHECK dout0_30 Vdout0_30ck72 = 0 time = 365
.meas tran vdout0_30ck72 FIND v(dout0_30) AT=365.025n

* CHECK dout0_31 Vdout0_31ck72 = 1.1 time = 365
.meas tran vdout0_31ck72 FIND v(dout0_31) AT=365.025n

* CHECK dout0_0 Vdout0_0ck73 = 0 time = 370
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=370.025n

* CHECK dout0_1 Vdout0_1ck73 = 1.1 time = 370
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=370.025n

* CHECK dout0_2 Vdout0_2ck73 = 1.1 time = 370
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=370.025n

* CHECK dout0_3 Vdout0_3ck73 = 1.1 time = 370
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=370.025n

* CHECK dout0_4 Vdout0_4ck73 = 0 time = 370
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=370.025n

* CHECK dout0_5 Vdout0_5ck73 = 0 time = 370
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=370.025n

* CHECK dout0_6 Vdout0_6ck73 = 0 time = 370
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=370.025n

* CHECK dout0_7 Vdout0_7ck73 = 1.1 time = 370
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=370.025n

* CHECK dout0_8 Vdout0_8ck73 = 0 time = 370
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=370.025n

* CHECK dout0_9 Vdout0_9ck73 = 1.1 time = 370
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=370.025n

* CHECK dout0_10 Vdout0_10ck73 = 1.1 time = 370
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=370.025n

* CHECK dout0_11 Vdout0_11ck73 = 1.1 time = 370
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=370.025n

* CHECK dout0_12 Vdout0_12ck73 = 1.1 time = 370
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=370.025n

* CHECK dout0_13 Vdout0_13ck73 = 0 time = 370
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=370.025n

* CHECK dout0_14 Vdout0_14ck73 = 1.1 time = 370
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=370.025n

* CHECK dout0_15 Vdout0_15ck73 = 1.1 time = 370
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=370.025n

* CHECK dout0_16 Vdout0_16ck73 = 0 time = 370
.meas tran vdout0_16ck73 FIND v(dout0_16) AT=370.025n

* CHECK dout0_17 Vdout0_17ck73 = 0 time = 370
.meas tran vdout0_17ck73 FIND v(dout0_17) AT=370.025n

* CHECK dout0_18 Vdout0_18ck73 = 1.1 time = 370
.meas tran vdout0_18ck73 FIND v(dout0_18) AT=370.025n

* CHECK dout0_19 Vdout0_19ck73 = 0 time = 370
.meas tran vdout0_19ck73 FIND v(dout0_19) AT=370.025n

* CHECK dout0_20 Vdout0_20ck73 = 1.1 time = 370
.meas tran vdout0_20ck73 FIND v(dout0_20) AT=370.025n

* CHECK dout0_21 Vdout0_21ck73 = 0 time = 370
.meas tran vdout0_21ck73 FIND v(dout0_21) AT=370.025n

* CHECK dout0_22 Vdout0_22ck73 = 0 time = 370
.meas tran vdout0_22ck73 FIND v(dout0_22) AT=370.025n

* CHECK dout0_23 Vdout0_23ck73 = 0 time = 370
.meas tran vdout0_23ck73 FIND v(dout0_23) AT=370.025n

* CHECK dout0_24 Vdout0_24ck73 = 0 time = 370
.meas tran vdout0_24ck73 FIND v(dout0_24) AT=370.025n

* CHECK dout0_25 Vdout0_25ck73 = 1.1 time = 370
.meas tran vdout0_25ck73 FIND v(dout0_25) AT=370.025n

* CHECK dout0_26 Vdout0_26ck73 = 1.1 time = 370
.meas tran vdout0_26ck73 FIND v(dout0_26) AT=370.025n

* CHECK dout0_27 Vdout0_27ck73 = 1.1 time = 370
.meas tran vdout0_27ck73 FIND v(dout0_27) AT=370.025n

* CHECK dout0_28 Vdout0_28ck73 = 1.1 time = 370
.meas tran vdout0_28ck73 FIND v(dout0_28) AT=370.025n

* CHECK dout0_29 Vdout0_29ck73 = 0 time = 370
.meas tran vdout0_29ck73 FIND v(dout0_29) AT=370.025n

* CHECK dout0_30 Vdout0_30ck73 = 1.1 time = 370
.meas tran vdout0_30ck73 FIND v(dout0_30) AT=370.025n

* CHECK dout0_31 Vdout0_31ck73 = 0 time = 370
.meas tran vdout0_31ck73 FIND v(dout0_31) AT=370.025n

* CHECK dout0_0 Vdout0_0ck76 = 0 time = 385
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=385.025n

* CHECK dout0_1 Vdout0_1ck76 = 1.1 time = 385
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=385.025n

* CHECK dout0_2 Vdout0_2ck76 = 0 time = 385
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=385.025n

* CHECK dout0_3 Vdout0_3ck76 = 0 time = 385
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=385.025n

* CHECK dout0_4 Vdout0_4ck76 = 0 time = 385
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=385.025n

* CHECK dout0_5 Vdout0_5ck76 = 0 time = 385
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=385.025n

* CHECK dout0_6 Vdout0_6ck76 = 1.1 time = 385
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=385.025n

* CHECK dout0_7 Vdout0_7ck76 = 0 time = 385
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=385.025n

* CHECK dout0_8 Vdout0_8ck76 = 1.1 time = 385
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=385.025n

* CHECK dout0_9 Vdout0_9ck76 = 1.1 time = 385
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=385.025n

* CHECK dout0_10 Vdout0_10ck76 = 1.1 time = 385
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=385.025n

* CHECK dout0_11 Vdout0_11ck76 = 0 time = 385
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=385.025n

* CHECK dout0_12 Vdout0_12ck76 = 0 time = 385
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=385.025n

* CHECK dout0_13 Vdout0_13ck76 = 1.1 time = 385
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=385.025n

* CHECK dout0_14 Vdout0_14ck76 = 1.1 time = 385
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=385.025n

* CHECK dout0_15 Vdout0_15ck76 = 1.1 time = 385
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=385.025n

* CHECK dout0_16 Vdout0_16ck76 = 1.1 time = 385
.meas tran vdout0_16ck76 FIND v(dout0_16) AT=385.025n

* CHECK dout0_17 Vdout0_17ck76 = 1.1 time = 385
.meas tran vdout0_17ck76 FIND v(dout0_17) AT=385.025n

* CHECK dout0_18 Vdout0_18ck76 = 0 time = 385
.meas tran vdout0_18ck76 FIND v(dout0_18) AT=385.025n

* CHECK dout0_19 Vdout0_19ck76 = 1.1 time = 385
.meas tran vdout0_19ck76 FIND v(dout0_19) AT=385.025n

* CHECK dout0_20 Vdout0_20ck76 = 1.1 time = 385
.meas tran vdout0_20ck76 FIND v(dout0_20) AT=385.025n

* CHECK dout0_21 Vdout0_21ck76 = 1.1 time = 385
.meas tran vdout0_21ck76 FIND v(dout0_21) AT=385.025n

* CHECK dout0_22 Vdout0_22ck76 = 1.1 time = 385
.meas tran vdout0_22ck76 FIND v(dout0_22) AT=385.025n

* CHECK dout0_23 Vdout0_23ck76 = 0 time = 385
.meas tran vdout0_23ck76 FIND v(dout0_23) AT=385.025n

* CHECK dout0_24 Vdout0_24ck76 = 1.1 time = 385
.meas tran vdout0_24ck76 FIND v(dout0_24) AT=385.025n

* CHECK dout0_25 Vdout0_25ck76 = 0 time = 385
.meas tran vdout0_25ck76 FIND v(dout0_25) AT=385.025n

* CHECK dout0_26 Vdout0_26ck76 = 1.1 time = 385
.meas tran vdout0_26ck76 FIND v(dout0_26) AT=385.025n

* CHECK dout0_27 Vdout0_27ck76 = 0 time = 385
.meas tran vdout0_27ck76 FIND v(dout0_27) AT=385.025n

* CHECK dout0_28 Vdout0_28ck76 = 1.1 time = 385
.meas tran vdout0_28ck76 FIND v(dout0_28) AT=385.025n

* CHECK dout0_29 Vdout0_29ck76 = 1.1 time = 385
.meas tran vdout0_29ck76 FIND v(dout0_29) AT=385.025n

* CHECK dout0_30 Vdout0_30ck76 = 0 time = 385
.meas tran vdout0_30ck76 FIND v(dout0_30) AT=385.025n

* CHECK dout0_31 Vdout0_31ck76 = 1.1 time = 385
.meas tran vdout0_31ck76 FIND v(dout0_31) AT=385.025n

* CHECK dout0_0 Vdout0_0ck77 = 0 time = 390
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=390.025n

* CHECK dout0_1 Vdout0_1ck77 = 0 time = 390
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=390.025n

* CHECK dout0_2 Vdout0_2ck77 = 1.1 time = 390
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=390.025n

* CHECK dout0_3 Vdout0_3ck77 = 1.1 time = 390
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=390.025n

* CHECK dout0_4 Vdout0_4ck77 = 1.1 time = 390
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=390.025n

* CHECK dout0_5 Vdout0_5ck77 = 1.1 time = 390
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=390.025n

* CHECK dout0_6 Vdout0_6ck77 = 1.1 time = 390
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=390.025n

* CHECK dout0_7 Vdout0_7ck77 = 1.1 time = 390
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=390.025n

* CHECK dout0_8 Vdout0_8ck77 = 1.1 time = 390
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=390.025n

* CHECK dout0_9 Vdout0_9ck77 = 1.1 time = 390
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=390.025n

* CHECK dout0_10 Vdout0_10ck77 = 0 time = 390
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=390.025n

* CHECK dout0_11 Vdout0_11ck77 = 0 time = 390
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=390.025n

* CHECK dout0_12 Vdout0_12ck77 = 0 time = 390
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=390.025n

* CHECK dout0_13 Vdout0_13ck77 = 1.1 time = 390
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=390.025n

* CHECK dout0_14 Vdout0_14ck77 = 0 time = 390
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=390.025n

* CHECK dout0_15 Vdout0_15ck77 = 0 time = 390
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=390.025n

* CHECK dout0_16 Vdout0_16ck77 = 1.1 time = 390
.meas tran vdout0_16ck77 FIND v(dout0_16) AT=390.025n

* CHECK dout0_17 Vdout0_17ck77 = 0 time = 390
.meas tran vdout0_17ck77 FIND v(dout0_17) AT=390.025n

* CHECK dout0_18 Vdout0_18ck77 = 1.1 time = 390
.meas tran vdout0_18ck77 FIND v(dout0_18) AT=390.025n

* CHECK dout0_19 Vdout0_19ck77 = 0 time = 390
.meas tran vdout0_19ck77 FIND v(dout0_19) AT=390.025n

* CHECK dout0_20 Vdout0_20ck77 = 1.1 time = 390
.meas tran vdout0_20ck77 FIND v(dout0_20) AT=390.025n

* CHECK dout0_21 Vdout0_21ck77 = 0 time = 390
.meas tran vdout0_21ck77 FIND v(dout0_21) AT=390.025n

* CHECK dout0_22 Vdout0_22ck77 = 1.1 time = 390
.meas tran vdout0_22ck77 FIND v(dout0_22) AT=390.025n

* CHECK dout0_23 Vdout0_23ck77 = 0 time = 390
.meas tran vdout0_23ck77 FIND v(dout0_23) AT=390.025n

* CHECK dout0_24 Vdout0_24ck77 = 0 time = 390
.meas tran vdout0_24ck77 FIND v(dout0_24) AT=390.025n

* CHECK dout0_25 Vdout0_25ck77 = 0 time = 390
.meas tran vdout0_25ck77 FIND v(dout0_25) AT=390.025n

* CHECK dout0_26 Vdout0_26ck77 = 1.1 time = 390
.meas tran vdout0_26ck77 FIND v(dout0_26) AT=390.025n

* CHECK dout0_27 Vdout0_27ck77 = 1.1 time = 390
.meas tran vdout0_27ck77 FIND v(dout0_27) AT=390.025n

* CHECK dout0_28 Vdout0_28ck77 = 0 time = 390
.meas tran vdout0_28ck77 FIND v(dout0_28) AT=390.025n

* CHECK dout0_29 Vdout0_29ck77 = 0 time = 390
.meas tran vdout0_29ck77 FIND v(dout0_29) AT=390.025n

* CHECK dout0_30 Vdout0_30ck77 = 1.1 time = 390
.meas tran vdout0_30ck77 FIND v(dout0_30) AT=390.025n

* CHECK dout0_31 Vdout0_31ck77 = 1.1 time = 390
.meas tran vdout0_31ck77 FIND v(dout0_31) AT=390.025n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 400
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=400.025n

* CHECK dout0_1 Vdout0_1ck79 = 1.1 time = 400
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=400.025n

* CHECK dout0_2 Vdout0_2ck79 = 1.1 time = 400
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=400.025n

* CHECK dout0_3 Vdout0_3ck79 = 0 time = 400
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=400.025n

* CHECK dout0_4 Vdout0_4ck79 = 1.1 time = 400
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=400.025n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 400
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=400.025n

* CHECK dout0_6 Vdout0_6ck79 = 0 time = 400
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=400.025n

* CHECK dout0_7 Vdout0_7ck79 = 0 time = 400
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=400.025n

* CHECK dout0_8 Vdout0_8ck79 = 0 time = 400
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=400.025n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 400
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=400.025n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 400
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=400.025n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 400
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=400.025n

* CHECK dout0_12 Vdout0_12ck79 = 0 time = 400
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=400.025n

* CHECK dout0_13 Vdout0_13ck79 = 1.1 time = 400
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=400.025n

* CHECK dout0_14 Vdout0_14ck79 = 0 time = 400
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=400.025n

* CHECK dout0_15 Vdout0_15ck79 = 0 time = 400
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=400.025n

* CHECK dout0_16 Vdout0_16ck79 = 1.1 time = 400
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=400.025n

* CHECK dout0_17 Vdout0_17ck79 = 1.1 time = 400
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=400.025n

* CHECK dout0_18 Vdout0_18ck79 = 0 time = 400
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=400.025n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 400
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=400.025n

* CHECK dout0_20 Vdout0_20ck79 = 1.1 time = 400
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=400.025n

* CHECK dout0_21 Vdout0_21ck79 = 1.1 time = 400
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=400.025n

* CHECK dout0_22 Vdout0_22ck79 = 0 time = 400
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=400.025n

* CHECK dout0_23 Vdout0_23ck79 = 1.1 time = 400
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=400.025n

* CHECK dout0_24 Vdout0_24ck79 = 0 time = 400
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=400.025n

* CHECK dout0_25 Vdout0_25ck79 = 1.1 time = 400
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=400.025n

* CHECK dout0_26 Vdout0_26ck79 = 0 time = 400
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=400.025n

* CHECK dout0_27 Vdout0_27ck79 = 0 time = 400
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=400.025n

* CHECK dout0_28 Vdout0_28ck79 = 0 time = 400
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=400.025n

* CHECK dout0_29 Vdout0_29ck79 = 0 time = 400
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=400.025n

* CHECK dout0_30 Vdout0_30ck79 = 0 time = 400
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=400.025n

* CHECK dout0_31 Vdout0_31ck79 = 0 time = 400
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=400.025n

* CHECK dout0_0 Vdout0_0ck81 = 0 time = 410
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=410.025n

* CHECK dout0_1 Vdout0_1ck81 = 1.1 time = 410
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=410.025n

* CHECK dout0_2 Vdout0_2ck81 = 1.1 time = 410
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=410.025n

* CHECK dout0_3 Vdout0_3ck81 = 1.1 time = 410
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=410.025n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 410
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=410.025n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 410
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=410.025n

* CHECK dout0_6 Vdout0_6ck81 = 0 time = 410
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=410.025n

* CHECK dout0_7 Vdout0_7ck81 = 1.1 time = 410
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=410.025n

* CHECK dout0_8 Vdout0_8ck81 = 0 time = 410
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=410.025n

* CHECK dout0_9 Vdout0_9ck81 = 1.1 time = 410
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=410.025n

* CHECK dout0_10 Vdout0_10ck81 = 1.1 time = 410
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=410.025n

* CHECK dout0_11 Vdout0_11ck81 = 1.1 time = 410
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=410.025n

* CHECK dout0_12 Vdout0_12ck81 = 1.1 time = 410
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=410.025n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 410
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=410.025n

* CHECK dout0_14 Vdout0_14ck81 = 1.1 time = 410
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=410.025n

* CHECK dout0_15 Vdout0_15ck81 = 1.1 time = 410
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=410.025n

* CHECK dout0_16 Vdout0_16ck81 = 0 time = 410
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=410.025n

* CHECK dout0_17 Vdout0_17ck81 = 0 time = 410
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=410.025n

* CHECK dout0_18 Vdout0_18ck81 = 1.1 time = 410
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=410.025n

* CHECK dout0_19 Vdout0_19ck81 = 0 time = 410
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=410.025n

* CHECK dout0_20 Vdout0_20ck81 = 1.1 time = 410
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=410.025n

* CHECK dout0_21 Vdout0_21ck81 = 0 time = 410
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=410.025n

* CHECK dout0_22 Vdout0_22ck81 = 0 time = 410
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=410.025n

* CHECK dout0_23 Vdout0_23ck81 = 0 time = 410
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=410.025n

* CHECK dout0_24 Vdout0_24ck81 = 0 time = 410
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=410.025n

* CHECK dout0_25 Vdout0_25ck81 = 1.1 time = 410
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=410.025n

* CHECK dout0_26 Vdout0_26ck81 = 1.1 time = 410
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=410.025n

* CHECK dout0_27 Vdout0_27ck81 = 1.1 time = 410
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=410.025n

* CHECK dout0_28 Vdout0_28ck81 = 1.1 time = 410
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=410.025n

* CHECK dout0_29 Vdout0_29ck81 = 0 time = 410
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=410.025n

* CHECK dout0_30 Vdout0_30ck81 = 1.1 time = 410
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=410.025n

* CHECK dout0_31 Vdout0_31ck81 = 0 time = 410
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=410.025n

* CHECK dout0_0 Vdout0_0ck82 = 0 time = 415
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=415.025n

* CHECK dout0_1 Vdout0_1ck82 = 1.1 time = 415
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=415.025n

* CHECK dout0_2 Vdout0_2ck82 = 1.1 time = 415
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=415.025n

* CHECK dout0_3 Vdout0_3ck82 = 1.1 time = 415
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=415.025n

* CHECK dout0_4 Vdout0_4ck82 = 0 time = 415
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=415.025n

* CHECK dout0_5 Vdout0_5ck82 = 0 time = 415
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=415.025n

* CHECK dout0_6 Vdout0_6ck82 = 0 time = 415
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=415.025n

* CHECK dout0_7 Vdout0_7ck82 = 1.1 time = 415
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=415.025n

* CHECK dout0_8 Vdout0_8ck82 = 0 time = 415
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=415.025n

* CHECK dout0_9 Vdout0_9ck82 = 1.1 time = 415
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=415.025n

* CHECK dout0_10 Vdout0_10ck82 = 1.1 time = 415
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=415.025n

* CHECK dout0_11 Vdout0_11ck82 = 1.1 time = 415
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=415.025n

* CHECK dout0_12 Vdout0_12ck82 = 1.1 time = 415
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=415.025n

* CHECK dout0_13 Vdout0_13ck82 = 0 time = 415
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=415.025n

* CHECK dout0_14 Vdout0_14ck82 = 1.1 time = 415
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=415.025n

* CHECK dout0_15 Vdout0_15ck82 = 1.1 time = 415
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=415.025n

* CHECK dout0_16 Vdout0_16ck82 = 0 time = 415
.meas tran vdout0_16ck82 FIND v(dout0_16) AT=415.025n

* CHECK dout0_17 Vdout0_17ck82 = 0 time = 415
.meas tran vdout0_17ck82 FIND v(dout0_17) AT=415.025n

* CHECK dout0_18 Vdout0_18ck82 = 1.1 time = 415
.meas tran vdout0_18ck82 FIND v(dout0_18) AT=415.025n

* CHECK dout0_19 Vdout0_19ck82 = 0 time = 415
.meas tran vdout0_19ck82 FIND v(dout0_19) AT=415.025n

* CHECK dout0_20 Vdout0_20ck82 = 1.1 time = 415
.meas tran vdout0_20ck82 FIND v(dout0_20) AT=415.025n

* CHECK dout0_21 Vdout0_21ck82 = 0 time = 415
.meas tran vdout0_21ck82 FIND v(dout0_21) AT=415.025n

* CHECK dout0_22 Vdout0_22ck82 = 0 time = 415
.meas tran vdout0_22ck82 FIND v(dout0_22) AT=415.025n

* CHECK dout0_23 Vdout0_23ck82 = 0 time = 415
.meas tran vdout0_23ck82 FIND v(dout0_23) AT=415.025n

* CHECK dout0_24 Vdout0_24ck82 = 0 time = 415
.meas tran vdout0_24ck82 FIND v(dout0_24) AT=415.025n

* CHECK dout0_25 Vdout0_25ck82 = 1.1 time = 415
.meas tran vdout0_25ck82 FIND v(dout0_25) AT=415.025n

* CHECK dout0_26 Vdout0_26ck82 = 1.1 time = 415
.meas tran vdout0_26ck82 FIND v(dout0_26) AT=415.025n

* CHECK dout0_27 Vdout0_27ck82 = 1.1 time = 415
.meas tran vdout0_27ck82 FIND v(dout0_27) AT=415.025n

* CHECK dout0_28 Vdout0_28ck82 = 1.1 time = 415
.meas tran vdout0_28ck82 FIND v(dout0_28) AT=415.025n

* CHECK dout0_29 Vdout0_29ck82 = 0 time = 415
.meas tran vdout0_29ck82 FIND v(dout0_29) AT=415.025n

* CHECK dout0_30 Vdout0_30ck82 = 1.1 time = 415
.meas tran vdout0_30ck82 FIND v(dout0_30) AT=415.025n

* CHECK dout0_31 Vdout0_31ck82 = 0 time = 415
.meas tran vdout0_31ck82 FIND v(dout0_31) AT=415.025n

* CHECK dout0_0 Vdout0_0ck83 = 1.1 time = 420
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=420.025n

* CHECK dout0_1 Vdout0_1ck83 = 0 time = 420
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=420.025n

* CHECK dout0_2 Vdout0_2ck83 = 0 time = 420
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=420.025n

* CHECK dout0_3 Vdout0_3ck83 = 1.1 time = 420
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=420.025n

* CHECK dout0_4 Vdout0_4ck83 = 1.1 time = 420
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=420.025n

* CHECK dout0_5 Vdout0_5ck83 = 1.1 time = 420
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=420.025n

* CHECK dout0_6 Vdout0_6ck83 = 0 time = 420
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=420.025n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 420
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=420.025n

* CHECK dout0_8 Vdout0_8ck83 = 0 time = 420
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=420.025n

* CHECK dout0_9 Vdout0_9ck83 = 1.1 time = 420
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=420.025n

* CHECK dout0_10 Vdout0_10ck83 = 1.1 time = 420
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=420.025n

* CHECK dout0_11 Vdout0_11ck83 = 0 time = 420
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=420.025n

* CHECK dout0_12 Vdout0_12ck83 = 0 time = 420
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=420.025n

* CHECK dout0_13 Vdout0_13ck83 = 1.1 time = 420
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=420.025n

* CHECK dout0_14 Vdout0_14ck83 = 1.1 time = 420
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=420.025n

* CHECK dout0_15 Vdout0_15ck83 = 1.1 time = 420
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=420.025n

* CHECK dout0_16 Vdout0_16ck83 = 1.1 time = 420
.meas tran vdout0_16ck83 FIND v(dout0_16) AT=420.025n

* CHECK dout0_17 Vdout0_17ck83 = 0 time = 420
.meas tran vdout0_17ck83 FIND v(dout0_17) AT=420.025n

* CHECK dout0_18 Vdout0_18ck83 = 1.1 time = 420
.meas tran vdout0_18ck83 FIND v(dout0_18) AT=420.025n

* CHECK dout0_19 Vdout0_19ck83 = 1.1 time = 420
.meas tran vdout0_19ck83 FIND v(dout0_19) AT=420.025n

* CHECK dout0_20 Vdout0_20ck83 = 0 time = 420
.meas tran vdout0_20ck83 FIND v(dout0_20) AT=420.025n

* CHECK dout0_21 Vdout0_21ck83 = 1.1 time = 420
.meas tran vdout0_21ck83 FIND v(dout0_21) AT=420.025n

* CHECK dout0_22 Vdout0_22ck83 = 0 time = 420
.meas tran vdout0_22ck83 FIND v(dout0_22) AT=420.025n

* CHECK dout0_23 Vdout0_23ck83 = 1.1 time = 420
.meas tran vdout0_23ck83 FIND v(dout0_23) AT=420.025n

* CHECK dout0_24 Vdout0_24ck83 = 1.1 time = 420
.meas tran vdout0_24ck83 FIND v(dout0_24) AT=420.025n

* CHECK dout0_25 Vdout0_25ck83 = 0 time = 420
.meas tran vdout0_25ck83 FIND v(dout0_25) AT=420.025n

* CHECK dout0_26 Vdout0_26ck83 = 0 time = 420
.meas tran vdout0_26ck83 FIND v(dout0_26) AT=420.025n

* CHECK dout0_27 Vdout0_27ck83 = 1.1 time = 420
.meas tran vdout0_27ck83 FIND v(dout0_27) AT=420.025n

* CHECK dout0_28 Vdout0_28ck83 = 1.1 time = 420
.meas tran vdout0_28ck83 FIND v(dout0_28) AT=420.025n

* CHECK dout0_29 Vdout0_29ck83 = 0 time = 420
.meas tran vdout0_29ck83 FIND v(dout0_29) AT=420.025n

* CHECK dout0_30 Vdout0_30ck83 = 1.1 time = 420
.meas tran vdout0_30ck83 FIND v(dout0_30) AT=420.025n

* CHECK dout0_31 Vdout0_31ck83 = 0 time = 420
.meas tran vdout0_31ck83 FIND v(dout0_31) AT=420.025n

* CHECK dout0_0 Vdout0_0ck84 = 1.1 time = 425
.meas tran vdout0_0ck84 FIND v(dout0_0) AT=425.025n

* CHECK dout0_1 Vdout0_1ck84 = 0 time = 425
.meas tran vdout0_1ck84 FIND v(dout0_1) AT=425.025n

* CHECK dout0_2 Vdout0_2ck84 = 0 time = 425
.meas tran vdout0_2ck84 FIND v(dout0_2) AT=425.025n

* CHECK dout0_3 Vdout0_3ck84 = 1.1 time = 425
.meas tran vdout0_3ck84 FIND v(dout0_3) AT=425.025n

* CHECK dout0_4 Vdout0_4ck84 = 1.1 time = 425
.meas tran vdout0_4ck84 FIND v(dout0_4) AT=425.025n

* CHECK dout0_5 Vdout0_5ck84 = 1.1 time = 425
.meas tran vdout0_5ck84 FIND v(dout0_5) AT=425.025n

* CHECK dout0_6 Vdout0_6ck84 = 0 time = 425
.meas tran vdout0_6ck84 FIND v(dout0_6) AT=425.025n

* CHECK dout0_7 Vdout0_7ck84 = 0 time = 425
.meas tran vdout0_7ck84 FIND v(dout0_7) AT=425.025n

* CHECK dout0_8 Vdout0_8ck84 = 0 time = 425
.meas tran vdout0_8ck84 FIND v(dout0_8) AT=425.025n

* CHECK dout0_9 Vdout0_9ck84 = 1.1 time = 425
.meas tran vdout0_9ck84 FIND v(dout0_9) AT=425.025n

* CHECK dout0_10 Vdout0_10ck84 = 1.1 time = 425
.meas tran vdout0_10ck84 FIND v(dout0_10) AT=425.025n

* CHECK dout0_11 Vdout0_11ck84 = 0 time = 425
.meas tran vdout0_11ck84 FIND v(dout0_11) AT=425.025n

* CHECK dout0_12 Vdout0_12ck84 = 0 time = 425
.meas tran vdout0_12ck84 FIND v(dout0_12) AT=425.025n

* CHECK dout0_13 Vdout0_13ck84 = 1.1 time = 425
.meas tran vdout0_13ck84 FIND v(dout0_13) AT=425.025n

* CHECK dout0_14 Vdout0_14ck84 = 1.1 time = 425
.meas tran vdout0_14ck84 FIND v(dout0_14) AT=425.025n

* CHECK dout0_15 Vdout0_15ck84 = 1.1 time = 425
.meas tran vdout0_15ck84 FIND v(dout0_15) AT=425.025n

* CHECK dout0_16 Vdout0_16ck84 = 1.1 time = 425
.meas tran vdout0_16ck84 FIND v(dout0_16) AT=425.025n

* CHECK dout0_17 Vdout0_17ck84 = 0 time = 425
.meas tran vdout0_17ck84 FIND v(dout0_17) AT=425.025n

* CHECK dout0_18 Vdout0_18ck84 = 1.1 time = 425
.meas tran vdout0_18ck84 FIND v(dout0_18) AT=425.025n

* CHECK dout0_19 Vdout0_19ck84 = 1.1 time = 425
.meas tran vdout0_19ck84 FIND v(dout0_19) AT=425.025n

* CHECK dout0_20 Vdout0_20ck84 = 0 time = 425
.meas tran vdout0_20ck84 FIND v(dout0_20) AT=425.025n

* CHECK dout0_21 Vdout0_21ck84 = 1.1 time = 425
.meas tran vdout0_21ck84 FIND v(dout0_21) AT=425.025n

* CHECK dout0_22 Vdout0_22ck84 = 0 time = 425
.meas tran vdout0_22ck84 FIND v(dout0_22) AT=425.025n

* CHECK dout0_23 Vdout0_23ck84 = 1.1 time = 425
.meas tran vdout0_23ck84 FIND v(dout0_23) AT=425.025n

* CHECK dout0_24 Vdout0_24ck84 = 1.1 time = 425
.meas tran vdout0_24ck84 FIND v(dout0_24) AT=425.025n

* CHECK dout0_25 Vdout0_25ck84 = 0 time = 425
.meas tran vdout0_25ck84 FIND v(dout0_25) AT=425.025n

* CHECK dout0_26 Vdout0_26ck84 = 0 time = 425
.meas tran vdout0_26ck84 FIND v(dout0_26) AT=425.025n

* CHECK dout0_27 Vdout0_27ck84 = 1.1 time = 425
.meas tran vdout0_27ck84 FIND v(dout0_27) AT=425.025n

* CHECK dout0_28 Vdout0_28ck84 = 1.1 time = 425
.meas tran vdout0_28ck84 FIND v(dout0_28) AT=425.025n

* CHECK dout0_29 Vdout0_29ck84 = 0 time = 425
.meas tran vdout0_29ck84 FIND v(dout0_29) AT=425.025n

* CHECK dout0_30 Vdout0_30ck84 = 1.1 time = 425
.meas tran vdout0_30ck84 FIND v(dout0_30) AT=425.025n

* CHECK dout0_31 Vdout0_31ck84 = 0 time = 425
.meas tran vdout0_31ck84 FIND v(dout0_31) AT=425.025n

* CHECK dout0_0 Vdout0_0ck85 = 0 time = 430
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=430.025n

* CHECK dout0_1 Vdout0_1ck85 = 1.1 time = 430
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=430.025n

* CHECK dout0_2 Vdout0_2ck85 = 1.1 time = 430
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=430.025n

* CHECK dout0_3 Vdout0_3ck85 = 1.1 time = 430
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=430.025n

* CHECK dout0_4 Vdout0_4ck85 = 0 time = 430
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=430.025n

* CHECK dout0_5 Vdout0_5ck85 = 0 time = 430
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=430.025n

* CHECK dout0_6 Vdout0_6ck85 = 0 time = 430
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=430.025n

* CHECK dout0_7 Vdout0_7ck85 = 1.1 time = 430
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=430.025n

* CHECK dout0_8 Vdout0_8ck85 = 0 time = 430
.meas tran vdout0_8ck85 FIND v(dout0_8) AT=430.025n

* CHECK dout0_9 Vdout0_9ck85 = 1.1 time = 430
.meas tran vdout0_9ck85 FIND v(dout0_9) AT=430.025n

* CHECK dout0_10 Vdout0_10ck85 = 1.1 time = 430
.meas tran vdout0_10ck85 FIND v(dout0_10) AT=430.025n

* CHECK dout0_11 Vdout0_11ck85 = 1.1 time = 430
.meas tran vdout0_11ck85 FIND v(dout0_11) AT=430.025n

* CHECK dout0_12 Vdout0_12ck85 = 1.1 time = 430
.meas tran vdout0_12ck85 FIND v(dout0_12) AT=430.025n

* CHECK dout0_13 Vdout0_13ck85 = 0 time = 430
.meas tran vdout0_13ck85 FIND v(dout0_13) AT=430.025n

* CHECK dout0_14 Vdout0_14ck85 = 1.1 time = 430
.meas tran vdout0_14ck85 FIND v(dout0_14) AT=430.025n

* CHECK dout0_15 Vdout0_15ck85 = 1.1 time = 430
.meas tran vdout0_15ck85 FIND v(dout0_15) AT=430.025n

* CHECK dout0_16 Vdout0_16ck85 = 0 time = 430
.meas tran vdout0_16ck85 FIND v(dout0_16) AT=430.025n

* CHECK dout0_17 Vdout0_17ck85 = 0 time = 430
.meas tran vdout0_17ck85 FIND v(dout0_17) AT=430.025n

* CHECK dout0_18 Vdout0_18ck85 = 1.1 time = 430
.meas tran vdout0_18ck85 FIND v(dout0_18) AT=430.025n

* CHECK dout0_19 Vdout0_19ck85 = 0 time = 430
.meas tran vdout0_19ck85 FIND v(dout0_19) AT=430.025n

* CHECK dout0_20 Vdout0_20ck85 = 1.1 time = 430
.meas tran vdout0_20ck85 FIND v(dout0_20) AT=430.025n

* CHECK dout0_21 Vdout0_21ck85 = 0 time = 430
.meas tran vdout0_21ck85 FIND v(dout0_21) AT=430.025n

* CHECK dout0_22 Vdout0_22ck85 = 0 time = 430
.meas tran vdout0_22ck85 FIND v(dout0_22) AT=430.025n

* CHECK dout0_23 Vdout0_23ck85 = 0 time = 430
.meas tran vdout0_23ck85 FIND v(dout0_23) AT=430.025n

* CHECK dout0_24 Vdout0_24ck85 = 0 time = 430
.meas tran vdout0_24ck85 FIND v(dout0_24) AT=430.025n

* CHECK dout0_25 Vdout0_25ck85 = 1.1 time = 430
.meas tran vdout0_25ck85 FIND v(dout0_25) AT=430.025n

* CHECK dout0_26 Vdout0_26ck85 = 1.1 time = 430
.meas tran vdout0_26ck85 FIND v(dout0_26) AT=430.025n

* CHECK dout0_27 Vdout0_27ck85 = 1.1 time = 430
.meas tran vdout0_27ck85 FIND v(dout0_27) AT=430.025n

* CHECK dout0_28 Vdout0_28ck85 = 1.1 time = 430
.meas tran vdout0_28ck85 FIND v(dout0_28) AT=430.025n

* CHECK dout0_29 Vdout0_29ck85 = 0 time = 430
.meas tran vdout0_29ck85 FIND v(dout0_29) AT=430.025n

* CHECK dout0_30 Vdout0_30ck85 = 1.1 time = 430
.meas tran vdout0_30ck85 FIND v(dout0_30) AT=430.025n

* CHECK dout0_31 Vdout0_31ck85 = 0 time = 430
.meas tran vdout0_31ck85 FIND v(dout0_31) AT=430.025n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 435
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=435.025n

* CHECK dout0_1 Vdout0_1ck86 = 0 time = 435
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=435.025n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 435
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=435.025n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 435
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=435.025n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 435
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=435.025n

* CHECK dout0_5 Vdout0_5ck86 = 0 time = 435
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=435.025n

* CHECK dout0_6 Vdout0_6ck86 = 1.1 time = 435
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=435.025n

* CHECK dout0_7 Vdout0_7ck86 = 0 time = 435
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=435.025n

* CHECK dout0_8 Vdout0_8ck86 = 0 time = 435
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=435.025n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 435
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=435.025n

* CHECK dout0_10 Vdout0_10ck86 = 1.1 time = 435
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=435.025n

* CHECK dout0_11 Vdout0_11ck86 = 1.1 time = 435
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=435.025n

* CHECK dout0_12 Vdout0_12ck86 = 0 time = 435
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=435.025n

* CHECK dout0_13 Vdout0_13ck86 = 0 time = 435
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=435.025n

* CHECK dout0_14 Vdout0_14ck86 = 0 time = 435
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=435.025n

* CHECK dout0_15 Vdout0_15ck86 = 0 time = 435
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=435.025n

* CHECK dout0_16 Vdout0_16ck86 = 1.1 time = 435
.meas tran vdout0_16ck86 FIND v(dout0_16) AT=435.025n

* CHECK dout0_17 Vdout0_17ck86 = 1.1 time = 435
.meas tran vdout0_17ck86 FIND v(dout0_17) AT=435.025n

* CHECK dout0_18 Vdout0_18ck86 = 1.1 time = 435
.meas tran vdout0_18ck86 FIND v(dout0_18) AT=435.025n

* CHECK dout0_19 Vdout0_19ck86 = 0 time = 435
.meas tran vdout0_19ck86 FIND v(dout0_19) AT=435.025n

* CHECK dout0_20 Vdout0_20ck86 = 0 time = 435
.meas tran vdout0_20ck86 FIND v(dout0_20) AT=435.025n

* CHECK dout0_21 Vdout0_21ck86 = 0 time = 435
.meas tran vdout0_21ck86 FIND v(dout0_21) AT=435.025n

* CHECK dout0_22 Vdout0_22ck86 = 1.1 time = 435
.meas tran vdout0_22ck86 FIND v(dout0_22) AT=435.025n

* CHECK dout0_23 Vdout0_23ck86 = 0 time = 435
.meas tran vdout0_23ck86 FIND v(dout0_23) AT=435.025n

* CHECK dout0_24 Vdout0_24ck86 = 0 time = 435
.meas tran vdout0_24ck86 FIND v(dout0_24) AT=435.025n

* CHECK dout0_25 Vdout0_25ck86 = 0 time = 435
.meas tran vdout0_25ck86 FIND v(dout0_25) AT=435.025n

* CHECK dout0_26 Vdout0_26ck86 = 0 time = 435
.meas tran vdout0_26ck86 FIND v(dout0_26) AT=435.025n

* CHECK dout0_27 Vdout0_27ck86 = 0 time = 435
.meas tran vdout0_27ck86 FIND v(dout0_27) AT=435.025n

* CHECK dout0_28 Vdout0_28ck86 = 0 time = 435
.meas tran vdout0_28ck86 FIND v(dout0_28) AT=435.025n

* CHECK dout0_29 Vdout0_29ck86 = 0 time = 435
.meas tran vdout0_29ck86 FIND v(dout0_29) AT=435.025n

* CHECK dout0_30 Vdout0_30ck86 = 1.1 time = 435
.meas tran vdout0_30ck86 FIND v(dout0_30) AT=435.025n

* CHECK dout0_31 Vdout0_31ck86 = 1.1 time = 435
.meas tran vdout0_31ck86 FIND v(dout0_31) AT=435.025n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 450
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=450.025n

* CHECK dout0_1 Vdout0_1ck89 = 1.1 time = 450
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=450.025n

* CHECK dout0_2 Vdout0_2ck89 = 1.1 time = 450
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=450.025n

* CHECK dout0_3 Vdout0_3ck89 = 0 time = 450
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=450.025n

* CHECK dout0_4 Vdout0_4ck89 = 1.1 time = 450
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=450.025n

* CHECK dout0_5 Vdout0_5ck89 = 0 time = 450
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=450.025n

* CHECK dout0_6 Vdout0_6ck89 = 0 time = 450
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=450.025n

* CHECK dout0_7 Vdout0_7ck89 = 0 time = 450
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=450.025n

* CHECK dout0_8 Vdout0_8ck89 = 0 time = 450
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=450.025n

* CHECK dout0_9 Vdout0_9ck89 = 0 time = 450
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=450.025n

* CHECK dout0_10 Vdout0_10ck89 = 0 time = 450
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=450.025n

* CHECK dout0_11 Vdout0_11ck89 = 0 time = 450
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=450.025n

* CHECK dout0_12 Vdout0_12ck89 = 0 time = 450
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=450.025n

* CHECK dout0_13 Vdout0_13ck89 = 1.1 time = 450
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=450.025n

* CHECK dout0_14 Vdout0_14ck89 = 0 time = 450
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=450.025n

* CHECK dout0_15 Vdout0_15ck89 = 0 time = 450
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=450.025n

* CHECK dout0_16 Vdout0_16ck89 = 1.1 time = 450
.meas tran vdout0_16ck89 FIND v(dout0_16) AT=450.025n

* CHECK dout0_17 Vdout0_17ck89 = 1.1 time = 450
.meas tran vdout0_17ck89 FIND v(dout0_17) AT=450.025n

* CHECK dout0_18 Vdout0_18ck89 = 0 time = 450
.meas tran vdout0_18ck89 FIND v(dout0_18) AT=450.025n

* CHECK dout0_19 Vdout0_19ck89 = 0 time = 450
.meas tran vdout0_19ck89 FIND v(dout0_19) AT=450.025n

* CHECK dout0_20 Vdout0_20ck89 = 1.1 time = 450
.meas tran vdout0_20ck89 FIND v(dout0_20) AT=450.025n

* CHECK dout0_21 Vdout0_21ck89 = 1.1 time = 450
.meas tran vdout0_21ck89 FIND v(dout0_21) AT=450.025n

* CHECK dout0_22 Vdout0_22ck89 = 0 time = 450
.meas tran vdout0_22ck89 FIND v(dout0_22) AT=450.025n

* CHECK dout0_23 Vdout0_23ck89 = 1.1 time = 450
.meas tran vdout0_23ck89 FIND v(dout0_23) AT=450.025n

* CHECK dout0_24 Vdout0_24ck89 = 0 time = 450
.meas tran vdout0_24ck89 FIND v(dout0_24) AT=450.025n

* CHECK dout0_25 Vdout0_25ck89 = 1.1 time = 450
.meas tran vdout0_25ck89 FIND v(dout0_25) AT=450.025n

* CHECK dout0_26 Vdout0_26ck89 = 0 time = 450
.meas tran vdout0_26ck89 FIND v(dout0_26) AT=450.025n

* CHECK dout0_27 Vdout0_27ck89 = 0 time = 450
.meas tran vdout0_27ck89 FIND v(dout0_27) AT=450.025n

* CHECK dout0_28 Vdout0_28ck89 = 0 time = 450
.meas tran vdout0_28ck89 FIND v(dout0_28) AT=450.025n

* CHECK dout0_29 Vdout0_29ck89 = 0 time = 450
.meas tran vdout0_29ck89 FIND v(dout0_29) AT=450.025n

* CHECK dout0_30 Vdout0_30ck89 = 0 time = 450
.meas tran vdout0_30ck89 FIND v(dout0_30) AT=450.025n

* CHECK dout0_31 Vdout0_31ck89 = 0 time = 450
.meas tran vdout0_31ck89 FIND v(dout0_31) AT=450.025n

* CHECK dout0_0 Vdout0_0ck90 = 1.1 time = 455
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=455.025n

* CHECK dout0_1 Vdout0_1ck90 = 0 time = 455
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=455.025n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 455
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=455.025n

* CHECK dout0_3 Vdout0_3ck90 = 1.1 time = 455
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=455.025n

* CHECK dout0_4 Vdout0_4ck90 = 1.1 time = 455
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=455.025n

* CHECK dout0_5 Vdout0_5ck90 = 1.1 time = 455
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=455.025n

* CHECK dout0_6 Vdout0_6ck90 = 1.1 time = 455
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=455.025n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 455
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=455.025n

* CHECK dout0_8 Vdout0_8ck90 = 1.1 time = 455
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=455.025n

* CHECK dout0_9 Vdout0_9ck90 = 1.1 time = 455
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=455.025n

* CHECK dout0_10 Vdout0_10ck90 = 0 time = 455
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=455.025n

* CHECK dout0_11 Vdout0_11ck90 = 1.1 time = 455
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=455.025n

* CHECK dout0_12 Vdout0_12ck90 = 0 time = 455
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=455.025n

* CHECK dout0_13 Vdout0_13ck90 = 0 time = 455
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=455.025n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 455
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=455.025n

* CHECK dout0_15 Vdout0_15ck90 = 1.1 time = 455
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=455.025n

* CHECK dout0_16 Vdout0_16ck90 = 0 time = 455
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=455.025n

* CHECK dout0_17 Vdout0_17ck90 = 1.1 time = 455
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=455.025n

* CHECK dout0_18 Vdout0_18ck90 = 1.1 time = 455
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=455.025n

* CHECK dout0_19 Vdout0_19ck90 = 1.1 time = 455
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=455.025n

* CHECK dout0_20 Vdout0_20ck90 = 1.1 time = 455
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=455.025n

* CHECK dout0_21 Vdout0_21ck90 = 0 time = 455
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=455.025n

* CHECK dout0_22 Vdout0_22ck90 = 0 time = 455
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=455.025n

* CHECK dout0_23 Vdout0_23ck90 = 0 time = 455
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=455.025n

* CHECK dout0_24 Vdout0_24ck90 = 1.1 time = 455
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=455.025n

* CHECK dout0_25 Vdout0_25ck90 = 0 time = 455
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=455.025n

* CHECK dout0_26 Vdout0_26ck90 = 0 time = 455
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=455.025n

* CHECK dout0_27 Vdout0_27ck90 = 0 time = 455
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=455.025n

* CHECK dout0_28 Vdout0_28ck90 = 0 time = 455
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=455.025n

* CHECK dout0_29 Vdout0_29ck90 = 0 time = 455
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=455.025n

* CHECK dout0_30 Vdout0_30ck90 = 0 time = 455
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=455.025n

* CHECK dout0_31 Vdout0_31ck90 = 0 time = 455
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=455.025n

* CHECK dout0_0 Vdout0_0ck91 = 0 time = 460
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=460.025n

* CHECK dout0_1 Vdout0_1ck91 = 1.1 time = 460
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=460.025n

* CHECK dout0_2 Vdout0_2ck91 = 1.1 time = 460
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=460.025n

* CHECK dout0_3 Vdout0_3ck91 = 0 time = 460
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=460.025n

* CHECK dout0_4 Vdout0_4ck91 = 1.1 time = 460
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=460.025n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 460
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=460.025n

* CHECK dout0_6 Vdout0_6ck91 = 0 time = 460
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=460.025n

* CHECK dout0_7 Vdout0_7ck91 = 0 time = 460
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=460.025n

* CHECK dout0_8 Vdout0_8ck91 = 0 time = 460
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=460.025n

* CHECK dout0_9 Vdout0_9ck91 = 0 time = 460
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=460.025n

* CHECK dout0_10 Vdout0_10ck91 = 0 time = 460
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=460.025n

* CHECK dout0_11 Vdout0_11ck91 = 0 time = 460
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=460.025n

* CHECK dout0_12 Vdout0_12ck91 = 0 time = 460
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=460.025n

* CHECK dout0_13 Vdout0_13ck91 = 1.1 time = 460
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=460.025n

* CHECK dout0_14 Vdout0_14ck91 = 0 time = 460
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=460.025n

* CHECK dout0_15 Vdout0_15ck91 = 0 time = 460
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=460.025n

* CHECK dout0_16 Vdout0_16ck91 = 1.1 time = 460
.meas tran vdout0_16ck91 FIND v(dout0_16) AT=460.025n

* CHECK dout0_17 Vdout0_17ck91 = 1.1 time = 460
.meas tran vdout0_17ck91 FIND v(dout0_17) AT=460.025n

* CHECK dout0_18 Vdout0_18ck91 = 0 time = 460
.meas tran vdout0_18ck91 FIND v(dout0_18) AT=460.025n

* CHECK dout0_19 Vdout0_19ck91 = 0 time = 460
.meas tran vdout0_19ck91 FIND v(dout0_19) AT=460.025n

* CHECK dout0_20 Vdout0_20ck91 = 1.1 time = 460
.meas tran vdout0_20ck91 FIND v(dout0_20) AT=460.025n

* CHECK dout0_21 Vdout0_21ck91 = 1.1 time = 460
.meas tran vdout0_21ck91 FIND v(dout0_21) AT=460.025n

* CHECK dout0_22 Vdout0_22ck91 = 0 time = 460
.meas tran vdout0_22ck91 FIND v(dout0_22) AT=460.025n

* CHECK dout0_23 Vdout0_23ck91 = 1.1 time = 460
.meas tran vdout0_23ck91 FIND v(dout0_23) AT=460.025n

* CHECK dout0_24 Vdout0_24ck91 = 0 time = 460
.meas tran vdout0_24ck91 FIND v(dout0_24) AT=460.025n

* CHECK dout0_25 Vdout0_25ck91 = 1.1 time = 460
.meas tran vdout0_25ck91 FIND v(dout0_25) AT=460.025n

* CHECK dout0_26 Vdout0_26ck91 = 0 time = 460
.meas tran vdout0_26ck91 FIND v(dout0_26) AT=460.025n

* CHECK dout0_27 Vdout0_27ck91 = 0 time = 460
.meas tran vdout0_27ck91 FIND v(dout0_27) AT=460.025n

* CHECK dout0_28 Vdout0_28ck91 = 0 time = 460
.meas tran vdout0_28ck91 FIND v(dout0_28) AT=460.025n

* CHECK dout0_29 Vdout0_29ck91 = 0 time = 460
.meas tran vdout0_29ck91 FIND v(dout0_29) AT=460.025n

* CHECK dout0_30 Vdout0_30ck91 = 0 time = 460
.meas tran vdout0_30ck91 FIND v(dout0_30) AT=460.025n

* CHECK dout0_31 Vdout0_31ck91 = 0 time = 460
.meas tran vdout0_31ck91 FIND v(dout0_31) AT=460.025n

* CHECK dout0_0 Vdout0_0ck92 = 0 time = 465
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=465.025n

* CHECK dout0_1 Vdout0_1ck92 = 1.1 time = 465
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=465.025n

* CHECK dout0_2 Vdout0_2ck92 = 0 time = 465
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=465.025n

* CHECK dout0_3 Vdout0_3ck92 = 0 time = 465
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=465.025n

* CHECK dout0_4 Vdout0_4ck92 = 0 time = 465
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=465.025n

* CHECK dout0_5 Vdout0_5ck92 = 0 time = 465
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=465.025n

* CHECK dout0_6 Vdout0_6ck92 = 1.1 time = 465
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=465.025n

* CHECK dout0_7 Vdout0_7ck92 = 0 time = 465
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=465.025n

* CHECK dout0_8 Vdout0_8ck92 = 1.1 time = 465
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=465.025n

* CHECK dout0_9 Vdout0_9ck92 = 1.1 time = 465
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=465.025n

* CHECK dout0_10 Vdout0_10ck92 = 1.1 time = 465
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=465.025n

* CHECK dout0_11 Vdout0_11ck92 = 0 time = 465
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=465.025n

* CHECK dout0_12 Vdout0_12ck92 = 0 time = 465
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=465.025n

* CHECK dout0_13 Vdout0_13ck92 = 1.1 time = 465
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=465.025n

* CHECK dout0_14 Vdout0_14ck92 = 1.1 time = 465
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=465.025n

* CHECK dout0_15 Vdout0_15ck92 = 1.1 time = 465
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=465.025n

* CHECK dout0_16 Vdout0_16ck92 = 1.1 time = 465
.meas tran vdout0_16ck92 FIND v(dout0_16) AT=465.025n

* CHECK dout0_17 Vdout0_17ck92 = 1.1 time = 465
.meas tran vdout0_17ck92 FIND v(dout0_17) AT=465.025n

* CHECK dout0_18 Vdout0_18ck92 = 0 time = 465
.meas tran vdout0_18ck92 FIND v(dout0_18) AT=465.025n

* CHECK dout0_19 Vdout0_19ck92 = 1.1 time = 465
.meas tran vdout0_19ck92 FIND v(dout0_19) AT=465.025n

* CHECK dout0_20 Vdout0_20ck92 = 1.1 time = 465
.meas tran vdout0_20ck92 FIND v(dout0_20) AT=465.025n

* CHECK dout0_21 Vdout0_21ck92 = 1.1 time = 465
.meas tran vdout0_21ck92 FIND v(dout0_21) AT=465.025n

* CHECK dout0_22 Vdout0_22ck92 = 1.1 time = 465
.meas tran vdout0_22ck92 FIND v(dout0_22) AT=465.025n

* CHECK dout0_23 Vdout0_23ck92 = 0 time = 465
.meas tran vdout0_23ck92 FIND v(dout0_23) AT=465.025n

* CHECK dout0_24 Vdout0_24ck92 = 1.1 time = 465
.meas tran vdout0_24ck92 FIND v(dout0_24) AT=465.025n

* CHECK dout0_25 Vdout0_25ck92 = 0 time = 465
.meas tran vdout0_25ck92 FIND v(dout0_25) AT=465.025n

* CHECK dout0_26 Vdout0_26ck92 = 1.1 time = 465
.meas tran vdout0_26ck92 FIND v(dout0_26) AT=465.025n

* CHECK dout0_27 Vdout0_27ck92 = 0 time = 465
.meas tran vdout0_27ck92 FIND v(dout0_27) AT=465.025n

* CHECK dout0_28 Vdout0_28ck92 = 1.1 time = 465
.meas tran vdout0_28ck92 FIND v(dout0_28) AT=465.025n

* CHECK dout0_29 Vdout0_29ck92 = 1.1 time = 465
.meas tran vdout0_29ck92 FIND v(dout0_29) AT=465.025n

* CHECK dout0_30 Vdout0_30ck92 = 0 time = 465
.meas tran vdout0_30ck92 FIND v(dout0_30) AT=465.025n

* CHECK dout0_31 Vdout0_31ck92 = 1.1 time = 465
.meas tran vdout0_31ck92 FIND v(dout0_31) AT=465.025n

* CHECK dout0_0 Vdout0_0ck93 = 1.1 time = 470
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=470.025n

* CHECK dout0_1 Vdout0_1ck93 = 0 time = 470
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=470.025n

* CHECK dout0_2 Vdout0_2ck93 = 1.1 time = 470
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=470.025n

* CHECK dout0_3 Vdout0_3ck93 = 1.1 time = 470
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=470.025n

* CHECK dout0_4 Vdout0_4ck93 = 1.1 time = 470
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=470.025n

* CHECK dout0_5 Vdout0_5ck93 = 1.1 time = 470
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=470.025n

* CHECK dout0_6 Vdout0_6ck93 = 1.1 time = 470
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=470.025n

* CHECK dout0_7 Vdout0_7ck93 = 1.1 time = 470
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=470.025n

* CHECK dout0_8 Vdout0_8ck93 = 1.1 time = 470
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=470.025n

* CHECK dout0_9 Vdout0_9ck93 = 1.1 time = 470
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=470.025n

* CHECK dout0_10 Vdout0_10ck93 = 1.1 time = 470
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=470.025n

* CHECK dout0_11 Vdout0_11ck93 = 0 time = 470
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=470.025n

* CHECK dout0_12 Vdout0_12ck93 = 0 time = 470
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=470.025n

* CHECK dout0_13 Vdout0_13ck93 = 1.1 time = 470
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=470.025n

* CHECK dout0_14 Vdout0_14ck93 = 1.1 time = 470
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=470.025n

* CHECK dout0_15 Vdout0_15ck93 = 1.1 time = 470
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=470.025n

* CHECK dout0_16 Vdout0_16ck93 = 1.1 time = 470
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=470.025n

* CHECK dout0_17 Vdout0_17ck93 = 0 time = 470
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=470.025n

* CHECK dout0_18 Vdout0_18ck93 = 1.1 time = 470
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=470.025n

* CHECK dout0_19 Vdout0_19ck93 = 0 time = 470
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=470.025n

* CHECK dout0_20 Vdout0_20ck93 = 1.1 time = 470
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=470.025n

* CHECK dout0_21 Vdout0_21ck93 = 1.1 time = 470
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=470.025n

* CHECK dout0_22 Vdout0_22ck93 = 0 time = 470
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=470.025n

* CHECK dout0_23 Vdout0_23ck93 = 0 time = 470
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=470.025n

* CHECK dout0_24 Vdout0_24ck93 = 0 time = 470
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=470.025n

* CHECK dout0_25 Vdout0_25ck93 = 0 time = 470
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=470.025n

* CHECK dout0_26 Vdout0_26ck93 = 0 time = 470
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=470.025n

* CHECK dout0_27 Vdout0_27ck93 = 1.1 time = 470
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=470.025n

* CHECK dout0_28 Vdout0_28ck93 = 0 time = 470
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=470.025n

* CHECK dout0_29 Vdout0_29ck93 = 0 time = 470
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=470.025n

* CHECK dout0_30 Vdout0_30ck93 = 1.1 time = 470
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=470.025n

* CHECK dout0_31 Vdout0_31ck93 = 1.1 time = 470
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=470.025n

* CHECK dout0_0 Vdout0_0ck94 = 0 time = 475
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=475.025n

* CHECK dout0_1 Vdout0_1ck94 = 1.1 time = 475
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=475.025n

* CHECK dout0_2 Vdout0_2ck94 = 1.1 time = 475
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=475.025n

* CHECK dout0_3 Vdout0_3ck94 = 0 time = 475
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=475.025n

* CHECK dout0_4 Vdout0_4ck94 = 1.1 time = 475
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=475.025n

* CHECK dout0_5 Vdout0_5ck94 = 0 time = 475
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=475.025n

* CHECK dout0_6 Vdout0_6ck94 = 0 time = 475
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=475.025n

* CHECK dout0_7 Vdout0_7ck94 = 0 time = 475
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=475.025n

* CHECK dout0_8 Vdout0_8ck94 = 0 time = 475
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=475.025n

* CHECK dout0_9 Vdout0_9ck94 = 0 time = 475
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=475.025n

* CHECK dout0_10 Vdout0_10ck94 = 0 time = 475
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=475.025n

* CHECK dout0_11 Vdout0_11ck94 = 0 time = 475
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=475.025n

* CHECK dout0_12 Vdout0_12ck94 = 0 time = 475
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=475.025n

* CHECK dout0_13 Vdout0_13ck94 = 1.1 time = 475
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=475.025n

* CHECK dout0_14 Vdout0_14ck94 = 0 time = 475
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=475.025n

* CHECK dout0_15 Vdout0_15ck94 = 0 time = 475
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=475.025n

* CHECK dout0_16 Vdout0_16ck94 = 1.1 time = 475
.meas tran vdout0_16ck94 FIND v(dout0_16) AT=475.025n

* CHECK dout0_17 Vdout0_17ck94 = 1.1 time = 475
.meas tran vdout0_17ck94 FIND v(dout0_17) AT=475.025n

* CHECK dout0_18 Vdout0_18ck94 = 0 time = 475
.meas tran vdout0_18ck94 FIND v(dout0_18) AT=475.025n

* CHECK dout0_19 Vdout0_19ck94 = 0 time = 475
.meas tran vdout0_19ck94 FIND v(dout0_19) AT=475.025n

* CHECK dout0_20 Vdout0_20ck94 = 1.1 time = 475
.meas tran vdout0_20ck94 FIND v(dout0_20) AT=475.025n

* CHECK dout0_21 Vdout0_21ck94 = 1.1 time = 475
.meas tran vdout0_21ck94 FIND v(dout0_21) AT=475.025n

* CHECK dout0_22 Vdout0_22ck94 = 0 time = 475
.meas tran vdout0_22ck94 FIND v(dout0_22) AT=475.025n

* CHECK dout0_23 Vdout0_23ck94 = 1.1 time = 475
.meas tran vdout0_23ck94 FIND v(dout0_23) AT=475.025n

* CHECK dout0_24 Vdout0_24ck94 = 0 time = 475
.meas tran vdout0_24ck94 FIND v(dout0_24) AT=475.025n

* CHECK dout0_25 Vdout0_25ck94 = 1.1 time = 475
.meas tran vdout0_25ck94 FIND v(dout0_25) AT=475.025n

* CHECK dout0_26 Vdout0_26ck94 = 0 time = 475
.meas tran vdout0_26ck94 FIND v(dout0_26) AT=475.025n

* CHECK dout0_27 Vdout0_27ck94 = 0 time = 475
.meas tran vdout0_27ck94 FIND v(dout0_27) AT=475.025n

* CHECK dout0_28 Vdout0_28ck94 = 0 time = 475
.meas tran vdout0_28ck94 FIND v(dout0_28) AT=475.025n

* CHECK dout0_29 Vdout0_29ck94 = 0 time = 475
.meas tran vdout0_29ck94 FIND v(dout0_29) AT=475.025n

* CHECK dout0_30 Vdout0_30ck94 = 0 time = 475
.meas tran vdout0_30ck94 FIND v(dout0_30) AT=475.025n

* CHECK dout0_31 Vdout0_31ck94 = 0 time = 475
.meas tran vdout0_31ck94 FIND v(dout0_31) AT=475.025n

* CHECK dout0_0 Vdout0_0ck95 = 0 time = 480
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=480.025n

* CHECK dout0_1 Vdout0_1ck95 = 0 time = 480
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=480.025n

* CHECK dout0_2 Vdout0_2ck95 = 1.1 time = 480
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=480.025n

* CHECK dout0_3 Vdout0_3ck95 = 1.1 time = 480
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=480.025n

* CHECK dout0_4 Vdout0_4ck95 = 1.1 time = 480
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=480.025n

* CHECK dout0_5 Vdout0_5ck95 = 1.1 time = 480
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=480.025n

* CHECK dout0_6 Vdout0_6ck95 = 1.1 time = 480
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=480.025n

* CHECK dout0_7 Vdout0_7ck95 = 1.1 time = 480
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=480.025n

* CHECK dout0_8 Vdout0_8ck95 = 1.1 time = 480
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=480.025n

* CHECK dout0_9 Vdout0_9ck95 = 1.1 time = 480
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=480.025n

* CHECK dout0_10 Vdout0_10ck95 = 0 time = 480
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=480.025n

* CHECK dout0_11 Vdout0_11ck95 = 0 time = 480
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=480.025n

* CHECK dout0_12 Vdout0_12ck95 = 0 time = 480
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=480.025n

* CHECK dout0_13 Vdout0_13ck95 = 1.1 time = 480
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=480.025n

* CHECK dout0_14 Vdout0_14ck95 = 0 time = 480
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=480.025n

* CHECK dout0_15 Vdout0_15ck95 = 0 time = 480
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=480.025n

* CHECK dout0_16 Vdout0_16ck95 = 1.1 time = 480
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=480.025n

* CHECK dout0_17 Vdout0_17ck95 = 0 time = 480
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=480.025n

* CHECK dout0_18 Vdout0_18ck95 = 1.1 time = 480
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=480.025n

* CHECK dout0_19 Vdout0_19ck95 = 0 time = 480
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=480.025n

* CHECK dout0_20 Vdout0_20ck95 = 1.1 time = 480
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=480.025n

* CHECK dout0_21 Vdout0_21ck95 = 0 time = 480
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=480.025n

* CHECK dout0_22 Vdout0_22ck95 = 1.1 time = 480
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=480.025n

* CHECK dout0_23 Vdout0_23ck95 = 0 time = 480
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=480.025n

* CHECK dout0_24 Vdout0_24ck95 = 0 time = 480
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=480.025n

* CHECK dout0_25 Vdout0_25ck95 = 0 time = 480
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=480.025n

* CHECK dout0_26 Vdout0_26ck95 = 1.1 time = 480
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=480.025n

* CHECK dout0_27 Vdout0_27ck95 = 1.1 time = 480
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=480.025n

* CHECK dout0_28 Vdout0_28ck95 = 0 time = 480
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=480.025n

* CHECK dout0_29 Vdout0_29ck95 = 0 time = 480
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=480.025n

* CHECK dout0_30 Vdout0_30ck95 = 1.1 time = 480
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=480.025n

* CHECK dout0_31 Vdout0_31ck95 = 1.1 time = 480
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=480.025n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 485
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=485.025n

* CHECK dout0_1 Vdout0_1ck96 = 1.1 time = 485
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=485.025n

* CHECK dout0_2 Vdout0_2ck96 = 1.1 time = 485
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=485.025n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 485
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=485.025n

* CHECK dout0_4 Vdout0_4ck96 = 1.1 time = 485
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=485.025n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 485
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=485.025n

* CHECK dout0_6 Vdout0_6ck96 = 0 time = 485
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=485.025n

* CHECK dout0_7 Vdout0_7ck96 = 0 time = 485
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=485.025n

* CHECK dout0_8 Vdout0_8ck96 = 0 time = 485
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=485.025n

* CHECK dout0_9 Vdout0_9ck96 = 0 time = 485
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=485.025n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 485
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=485.025n

* CHECK dout0_11 Vdout0_11ck96 = 0 time = 485
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=485.025n

* CHECK dout0_12 Vdout0_12ck96 = 0 time = 485
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=485.025n

* CHECK dout0_13 Vdout0_13ck96 = 1.1 time = 485
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=485.025n

* CHECK dout0_14 Vdout0_14ck96 = 0 time = 485
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=485.025n

* CHECK dout0_15 Vdout0_15ck96 = 0 time = 485
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=485.025n

* CHECK dout0_16 Vdout0_16ck96 = 1.1 time = 485
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=485.025n

* CHECK dout0_17 Vdout0_17ck96 = 1.1 time = 485
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=485.025n

* CHECK dout0_18 Vdout0_18ck96 = 0 time = 485
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=485.025n

* CHECK dout0_19 Vdout0_19ck96 = 0 time = 485
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=485.025n

* CHECK dout0_20 Vdout0_20ck96 = 1.1 time = 485
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=485.025n

* CHECK dout0_21 Vdout0_21ck96 = 1.1 time = 485
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=485.025n

* CHECK dout0_22 Vdout0_22ck96 = 0 time = 485
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=485.025n

* CHECK dout0_23 Vdout0_23ck96 = 1.1 time = 485
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=485.025n

* CHECK dout0_24 Vdout0_24ck96 = 0 time = 485
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=485.025n

* CHECK dout0_25 Vdout0_25ck96 = 1.1 time = 485
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=485.025n

* CHECK dout0_26 Vdout0_26ck96 = 0 time = 485
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=485.025n

* CHECK dout0_27 Vdout0_27ck96 = 0 time = 485
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=485.025n

* CHECK dout0_28 Vdout0_28ck96 = 0 time = 485
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=485.025n

* CHECK dout0_29 Vdout0_29ck96 = 0 time = 485
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=485.025n

* CHECK dout0_30 Vdout0_30ck96 = 0 time = 485
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=485.025n

* CHECK dout0_31 Vdout0_31ck96 = 0 time = 485
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=485.025n

* CHECK dout0_0 Vdout0_0ck98 = 0 time = 495
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=495.025n

* CHECK dout0_1 Vdout0_1ck98 = 1.1 time = 495
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=495.025n

* CHECK dout0_2 Vdout0_2ck98 = 1.1 time = 495
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=495.025n

* CHECK dout0_3 Vdout0_3ck98 = 0 time = 495
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=495.025n

* CHECK dout0_4 Vdout0_4ck98 = 1.1 time = 495
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=495.025n

* CHECK dout0_5 Vdout0_5ck98 = 0 time = 495
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=495.025n

* CHECK dout0_6 Vdout0_6ck98 = 0 time = 495
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=495.025n

* CHECK dout0_7 Vdout0_7ck98 = 0 time = 495
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=495.025n

* CHECK dout0_8 Vdout0_8ck98 = 0 time = 495
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=495.025n

* CHECK dout0_9 Vdout0_9ck98 = 0 time = 495
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=495.025n

* CHECK dout0_10 Vdout0_10ck98 = 0 time = 495
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=495.025n

* CHECK dout0_11 Vdout0_11ck98 = 0 time = 495
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=495.025n

* CHECK dout0_12 Vdout0_12ck98 = 0 time = 495
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=495.025n

* CHECK dout0_13 Vdout0_13ck98 = 1.1 time = 495
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=495.025n

* CHECK dout0_14 Vdout0_14ck98 = 0 time = 495
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=495.025n

* CHECK dout0_15 Vdout0_15ck98 = 0 time = 495
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=495.025n

* CHECK dout0_16 Vdout0_16ck98 = 1.1 time = 495
.meas tran vdout0_16ck98 FIND v(dout0_16) AT=495.025n

* CHECK dout0_17 Vdout0_17ck98 = 1.1 time = 495
.meas tran vdout0_17ck98 FIND v(dout0_17) AT=495.025n

* CHECK dout0_18 Vdout0_18ck98 = 0 time = 495
.meas tran vdout0_18ck98 FIND v(dout0_18) AT=495.025n

* CHECK dout0_19 Vdout0_19ck98 = 0 time = 495
.meas tran vdout0_19ck98 FIND v(dout0_19) AT=495.025n

* CHECK dout0_20 Vdout0_20ck98 = 1.1 time = 495
.meas tran vdout0_20ck98 FIND v(dout0_20) AT=495.025n

* CHECK dout0_21 Vdout0_21ck98 = 1.1 time = 495
.meas tran vdout0_21ck98 FIND v(dout0_21) AT=495.025n

* CHECK dout0_22 Vdout0_22ck98 = 0 time = 495
.meas tran vdout0_22ck98 FIND v(dout0_22) AT=495.025n

* CHECK dout0_23 Vdout0_23ck98 = 1.1 time = 495
.meas tran vdout0_23ck98 FIND v(dout0_23) AT=495.025n

* CHECK dout0_24 Vdout0_24ck98 = 0 time = 495
.meas tran vdout0_24ck98 FIND v(dout0_24) AT=495.025n

* CHECK dout0_25 Vdout0_25ck98 = 1.1 time = 495
.meas tran vdout0_25ck98 FIND v(dout0_25) AT=495.025n

* CHECK dout0_26 Vdout0_26ck98 = 0 time = 495
.meas tran vdout0_26ck98 FIND v(dout0_26) AT=495.025n

* CHECK dout0_27 Vdout0_27ck98 = 0 time = 495
.meas tran vdout0_27ck98 FIND v(dout0_27) AT=495.025n

* CHECK dout0_28 Vdout0_28ck98 = 0 time = 495
.meas tran vdout0_28ck98 FIND v(dout0_28) AT=495.025n

* CHECK dout0_29 Vdout0_29ck98 = 0 time = 495
.meas tran vdout0_29ck98 FIND v(dout0_29) AT=495.025n

* CHECK dout0_30 Vdout0_30ck98 = 0 time = 495
.meas tran vdout0_30ck98 FIND v(dout0_30) AT=495.025n

* CHECK dout0_31 Vdout0_31ck98 = 0 time = 495
.meas tran vdout0_31ck98 FIND v(dout0_31) AT=495.025n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 515
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=515.025n

* CHECK dout0_1 Vdout0_1ck102 = 0 time = 515
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=515.025n

* CHECK dout0_2 Vdout0_2ck102 = 0 time = 515
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=515.025n

* CHECK dout0_3 Vdout0_3ck102 = 1.1 time = 515
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=515.025n

* CHECK dout0_4 Vdout0_4ck102 = 0 time = 515
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=515.025n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 515
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=515.025n

* CHECK dout0_6 Vdout0_6ck102 = 0 time = 515
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=515.025n

* CHECK dout0_7 Vdout0_7ck102 = 0 time = 515
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=515.025n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 515
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=515.025n

* CHECK dout0_9 Vdout0_9ck102 = 0 time = 515
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=515.025n

* CHECK dout0_10 Vdout0_10ck102 = 0 time = 515
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=515.025n

* CHECK dout0_11 Vdout0_11ck102 = 1.1 time = 515
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=515.025n

* CHECK dout0_12 Vdout0_12ck102 = 1.1 time = 515
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=515.025n

* CHECK dout0_13 Vdout0_13ck102 = 1.1 time = 515
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=515.025n

* CHECK dout0_14 Vdout0_14ck102 = 1.1 time = 515
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=515.025n

* CHECK dout0_15 Vdout0_15ck102 = 0 time = 515
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=515.025n

* CHECK dout0_16 Vdout0_16ck102 = 1.1 time = 515
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=515.025n

* CHECK dout0_17 Vdout0_17ck102 = 0 time = 515
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=515.025n

* CHECK dout0_18 Vdout0_18ck102 = 0 time = 515
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=515.025n

* CHECK dout0_19 Vdout0_19ck102 = 1.1 time = 515
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=515.025n

* CHECK dout0_20 Vdout0_20ck102 = 0 time = 515
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=515.025n

* CHECK dout0_21 Vdout0_21ck102 = 0 time = 515
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=515.025n

* CHECK dout0_22 Vdout0_22ck102 = 1.1 time = 515
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=515.025n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 515
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=515.025n

* CHECK dout0_24 Vdout0_24ck102 = 0 time = 515
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=515.025n

* CHECK dout0_25 Vdout0_25ck102 = 0 time = 515
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=515.025n

* CHECK dout0_26 Vdout0_26ck102 = 1.1 time = 515
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=515.025n

* CHECK dout0_27 Vdout0_27ck102 = 0 time = 515
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=515.025n

* CHECK dout0_28 Vdout0_28ck102 = 0 time = 515
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=515.025n

* CHECK dout0_29 Vdout0_29ck102 = 1.1 time = 515
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=515.025n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 515
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=515.025n

* CHECK dout0_31 Vdout0_31ck102 = 0 time = 515
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=515.025n

* CHECK dout0_0 Vdout0_0ck103 = 0 time = 520
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=520.025n

* CHECK dout0_1 Vdout0_1ck103 = 1.1 time = 520
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=520.025n

* CHECK dout0_2 Vdout0_2ck103 = 1.1 time = 520
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=520.025n

* CHECK dout0_3 Vdout0_3ck103 = 1.1 time = 520
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=520.025n

* CHECK dout0_4 Vdout0_4ck103 = 0 time = 520
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=520.025n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 520
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=520.025n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 520
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=520.025n

* CHECK dout0_7 Vdout0_7ck103 = 1.1 time = 520
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=520.025n

* CHECK dout0_8 Vdout0_8ck103 = 0 time = 520
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=520.025n

* CHECK dout0_9 Vdout0_9ck103 = 1.1 time = 520
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=520.025n

* CHECK dout0_10 Vdout0_10ck103 = 1.1 time = 520
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=520.025n

* CHECK dout0_11 Vdout0_11ck103 = 1.1 time = 520
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=520.025n

* CHECK dout0_12 Vdout0_12ck103 = 1.1 time = 520
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=520.025n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 520
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=520.025n

* CHECK dout0_14 Vdout0_14ck103 = 1.1 time = 520
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=520.025n

* CHECK dout0_15 Vdout0_15ck103 = 1.1 time = 520
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=520.025n

* CHECK dout0_16 Vdout0_16ck103 = 0 time = 520
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=520.025n

* CHECK dout0_17 Vdout0_17ck103 = 0 time = 520
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=520.025n

* CHECK dout0_18 Vdout0_18ck103 = 1.1 time = 520
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=520.025n

* CHECK dout0_19 Vdout0_19ck103 = 0 time = 520
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=520.025n

* CHECK dout0_20 Vdout0_20ck103 = 1.1 time = 520
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=520.025n

* CHECK dout0_21 Vdout0_21ck103 = 0 time = 520
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=520.025n

* CHECK dout0_22 Vdout0_22ck103 = 0 time = 520
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=520.025n

* CHECK dout0_23 Vdout0_23ck103 = 0 time = 520
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=520.025n

* CHECK dout0_24 Vdout0_24ck103 = 0 time = 520
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=520.025n

* CHECK dout0_25 Vdout0_25ck103 = 1.1 time = 520
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=520.025n

* CHECK dout0_26 Vdout0_26ck103 = 1.1 time = 520
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=520.025n

* CHECK dout0_27 Vdout0_27ck103 = 1.1 time = 520
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=520.025n

* CHECK dout0_28 Vdout0_28ck103 = 1.1 time = 520
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=520.025n

* CHECK dout0_29 Vdout0_29ck103 = 0 time = 520
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=520.025n

* CHECK dout0_30 Vdout0_30ck103 = 1.1 time = 520
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=520.025n

* CHECK dout0_31 Vdout0_31ck103 = 0 time = 520
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=520.025n

* CHECK dout0_0 Vdout0_0ck107 = 0 time = 540
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=540.025n

* CHECK dout0_1 Vdout0_1ck107 = 0 time = 540
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=540.025n

* CHECK dout0_2 Vdout0_2ck107 = 1.1 time = 540
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=540.025n

* CHECK dout0_3 Vdout0_3ck107 = 1.1 time = 540
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=540.025n

* CHECK dout0_4 Vdout0_4ck107 = 1.1 time = 540
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=540.025n

* CHECK dout0_5 Vdout0_5ck107 = 1.1 time = 540
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=540.025n

* CHECK dout0_6 Vdout0_6ck107 = 1.1 time = 540
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=540.025n

* CHECK dout0_7 Vdout0_7ck107 = 1.1 time = 540
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=540.025n

* CHECK dout0_8 Vdout0_8ck107 = 1.1 time = 540
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=540.025n

* CHECK dout0_9 Vdout0_9ck107 = 1.1 time = 540
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=540.025n

* CHECK dout0_10 Vdout0_10ck107 = 0 time = 540
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=540.025n

* CHECK dout0_11 Vdout0_11ck107 = 0 time = 540
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=540.025n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 540
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=540.025n

* CHECK dout0_13 Vdout0_13ck107 = 1.1 time = 540
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=540.025n

* CHECK dout0_14 Vdout0_14ck107 = 0 time = 540
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=540.025n

* CHECK dout0_15 Vdout0_15ck107 = 0 time = 540
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=540.025n

* CHECK dout0_16 Vdout0_16ck107 = 1.1 time = 540
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=540.025n

* CHECK dout0_17 Vdout0_17ck107 = 0 time = 540
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=540.025n

* CHECK dout0_18 Vdout0_18ck107 = 1.1 time = 540
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=540.025n

* CHECK dout0_19 Vdout0_19ck107 = 0 time = 540
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=540.025n

* CHECK dout0_20 Vdout0_20ck107 = 1.1 time = 540
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=540.025n

* CHECK dout0_21 Vdout0_21ck107 = 0 time = 540
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=540.025n

* CHECK dout0_22 Vdout0_22ck107 = 1.1 time = 540
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=540.025n

* CHECK dout0_23 Vdout0_23ck107 = 0 time = 540
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=540.025n

* CHECK dout0_24 Vdout0_24ck107 = 0 time = 540
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=540.025n

* CHECK dout0_25 Vdout0_25ck107 = 0 time = 540
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=540.025n

* CHECK dout0_26 Vdout0_26ck107 = 1.1 time = 540
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=540.025n

* CHECK dout0_27 Vdout0_27ck107 = 1.1 time = 540
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=540.025n

* CHECK dout0_28 Vdout0_28ck107 = 0 time = 540
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=540.025n

* CHECK dout0_29 Vdout0_29ck107 = 0 time = 540
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=540.025n

* CHECK dout0_30 Vdout0_30ck107 = 1.1 time = 540
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=540.025n

* CHECK dout0_31 Vdout0_31ck107 = 1.1 time = 540
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=540.025n

* CHECK dout0_0 Vdout0_0ck108 = 1.1 time = 545
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=545.025n

* CHECK dout0_1 Vdout0_1ck108 = 0 time = 545
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=545.025n

* CHECK dout0_2 Vdout0_2ck108 = 0 time = 545
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=545.025n

* CHECK dout0_3 Vdout0_3ck108 = 1.1 time = 545
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=545.025n

* CHECK dout0_4 Vdout0_4ck108 = 1.1 time = 545
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=545.025n

* CHECK dout0_5 Vdout0_5ck108 = 1.1 time = 545
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=545.025n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 545
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=545.025n

* CHECK dout0_7 Vdout0_7ck108 = 0 time = 545
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=545.025n

* CHECK dout0_8 Vdout0_8ck108 = 0 time = 545
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=545.025n

* CHECK dout0_9 Vdout0_9ck108 = 1.1 time = 545
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=545.025n

* CHECK dout0_10 Vdout0_10ck108 = 1.1 time = 545
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=545.025n

* CHECK dout0_11 Vdout0_11ck108 = 0 time = 545
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=545.025n

* CHECK dout0_12 Vdout0_12ck108 = 0 time = 545
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=545.025n

* CHECK dout0_13 Vdout0_13ck108 = 1.1 time = 545
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=545.025n

* CHECK dout0_14 Vdout0_14ck108 = 1.1 time = 545
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=545.025n

* CHECK dout0_15 Vdout0_15ck108 = 1.1 time = 545
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=545.025n

* CHECK dout0_16 Vdout0_16ck108 = 1.1 time = 545
.meas tran vdout0_16ck108 FIND v(dout0_16) AT=545.025n

* CHECK dout0_17 Vdout0_17ck108 = 0 time = 545
.meas tran vdout0_17ck108 FIND v(dout0_17) AT=545.025n

* CHECK dout0_18 Vdout0_18ck108 = 1.1 time = 545
.meas tran vdout0_18ck108 FIND v(dout0_18) AT=545.025n

* CHECK dout0_19 Vdout0_19ck108 = 1.1 time = 545
.meas tran vdout0_19ck108 FIND v(dout0_19) AT=545.025n

* CHECK dout0_20 Vdout0_20ck108 = 0 time = 545
.meas tran vdout0_20ck108 FIND v(dout0_20) AT=545.025n

* CHECK dout0_21 Vdout0_21ck108 = 1.1 time = 545
.meas tran vdout0_21ck108 FIND v(dout0_21) AT=545.025n

* CHECK dout0_22 Vdout0_22ck108 = 0 time = 545
.meas tran vdout0_22ck108 FIND v(dout0_22) AT=545.025n

* CHECK dout0_23 Vdout0_23ck108 = 1.1 time = 545
.meas tran vdout0_23ck108 FIND v(dout0_23) AT=545.025n

* CHECK dout0_24 Vdout0_24ck108 = 1.1 time = 545
.meas tran vdout0_24ck108 FIND v(dout0_24) AT=545.025n

* CHECK dout0_25 Vdout0_25ck108 = 0 time = 545
.meas tran vdout0_25ck108 FIND v(dout0_25) AT=545.025n

* CHECK dout0_26 Vdout0_26ck108 = 0 time = 545
.meas tran vdout0_26ck108 FIND v(dout0_26) AT=545.025n

* CHECK dout0_27 Vdout0_27ck108 = 1.1 time = 545
.meas tran vdout0_27ck108 FIND v(dout0_27) AT=545.025n

* CHECK dout0_28 Vdout0_28ck108 = 1.1 time = 545
.meas tran vdout0_28ck108 FIND v(dout0_28) AT=545.025n

* CHECK dout0_29 Vdout0_29ck108 = 0 time = 545
.meas tran vdout0_29ck108 FIND v(dout0_29) AT=545.025n

* CHECK dout0_30 Vdout0_30ck108 = 1.1 time = 545
.meas tran vdout0_30ck108 FIND v(dout0_30) AT=545.025n

* CHECK dout0_31 Vdout0_31ck108 = 0 time = 545
.meas tran vdout0_31ck108 FIND v(dout0_31) AT=545.025n

* CHECK dout0_0 Vdout0_0ck111 = 1.1 time = 560
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=560.025n

* CHECK dout0_1 Vdout0_1ck111 = 0 time = 560
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=560.025n

* CHECK dout0_2 Vdout0_2ck111 = 1.1 time = 560
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=560.025n

* CHECK dout0_3 Vdout0_3ck111 = 1.1 time = 560
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=560.025n

* CHECK dout0_4 Vdout0_4ck111 = 1.1 time = 560
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=560.025n

* CHECK dout0_5 Vdout0_5ck111 = 1.1 time = 560
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=560.025n

* CHECK dout0_6 Vdout0_6ck111 = 1.1 time = 560
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=560.025n

* CHECK dout0_7 Vdout0_7ck111 = 1.1 time = 560
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=560.025n

* CHECK dout0_8 Vdout0_8ck111 = 1.1 time = 560
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=560.025n

* CHECK dout0_9 Vdout0_9ck111 = 1.1 time = 560
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=560.025n

* CHECK dout0_10 Vdout0_10ck111 = 1.1 time = 560
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=560.025n

* CHECK dout0_11 Vdout0_11ck111 = 0 time = 560
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=560.025n

* CHECK dout0_12 Vdout0_12ck111 = 0 time = 560
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=560.025n

* CHECK dout0_13 Vdout0_13ck111 = 1.1 time = 560
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=560.025n

* CHECK dout0_14 Vdout0_14ck111 = 1.1 time = 560
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=560.025n

* CHECK dout0_15 Vdout0_15ck111 = 1.1 time = 560
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=560.025n

* CHECK dout0_16 Vdout0_16ck111 = 1.1 time = 560
.meas tran vdout0_16ck111 FIND v(dout0_16) AT=560.025n

* CHECK dout0_17 Vdout0_17ck111 = 0 time = 560
.meas tran vdout0_17ck111 FIND v(dout0_17) AT=560.025n

* CHECK dout0_18 Vdout0_18ck111 = 1.1 time = 560
.meas tran vdout0_18ck111 FIND v(dout0_18) AT=560.025n

* CHECK dout0_19 Vdout0_19ck111 = 0 time = 560
.meas tran vdout0_19ck111 FIND v(dout0_19) AT=560.025n

* CHECK dout0_20 Vdout0_20ck111 = 1.1 time = 560
.meas tran vdout0_20ck111 FIND v(dout0_20) AT=560.025n

* CHECK dout0_21 Vdout0_21ck111 = 1.1 time = 560
.meas tran vdout0_21ck111 FIND v(dout0_21) AT=560.025n

* CHECK dout0_22 Vdout0_22ck111 = 0 time = 560
.meas tran vdout0_22ck111 FIND v(dout0_22) AT=560.025n

* CHECK dout0_23 Vdout0_23ck111 = 0 time = 560
.meas tran vdout0_23ck111 FIND v(dout0_23) AT=560.025n

* CHECK dout0_24 Vdout0_24ck111 = 0 time = 560
.meas tran vdout0_24ck111 FIND v(dout0_24) AT=560.025n

* CHECK dout0_25 Vdout0_25ck111 = 0 time = 560
.meas tran vdout0_25ck111 FIND v(dout0_25) AT=560.025n

* CHECK dout0_26 Vdout0_26ck111 = 0 time = 560
.meas tran vdout0_26ck111 FIND v(dout0_26) AT=560.025n

* CHECK dout0_27 Vdout0_27ck111 = 1.1 time = 560
.meas tran vdout0_27ck111 FIND v(dout0_27) AT=560.025n

* CHECK dout0_28 Vdout0_28ck111 = 0 time = 560
.meas tran vdout0_28ck111 FIND v(dout0_28) AT=560.025n

* CHECK dout0_29 Vdout0_29ck111 = 0 time = 560
.meas tran vdout0_29ck111 FIND v(dout0_29) AT=560.025n

* CHECK dout0_30 Vdout0_30ck111 = 1.1 time = 560
.meas tran vdout0_30ck111 FIND v(dout0_30) AT=560.025n

* CHECK dout0_31 Vdout0_31ck111 = 1.1 time = 560
.meas tran vdout0_31ck111 FIND v(dout0_31) AT=560.025n

* CHECK dout0_0 Vdout0_0ck113 = 0 time = 570
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=570.025n

* CHECK dout0_1 Vdout0_1ck113 = 0 time = 570
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=570.025n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 570
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=570.025n

* CHECK dout0_3 Vdout0_3ck113 = 0 time = 570
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=570.025n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 570
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=570.025n

* CHECK dout0_5 Vdout0_5ck113 = 0 time = 570
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=570.025n

* CHECK dout0_6 Vdout0_6ck113 = 0 time = 570
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=570.025n

* CHECK dout0_7 Vdout0_7ck113 = 0 time = 570
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=570.025n

* CHECK dout0_8 Vdout0_8ck113 = 0 time = 570
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=570.025n

* CHECK dout0_9 Vdout0_9ck113 = 1.1 time = 570
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=570.025n

* CHECK dout0_10 Vdout0_10ck113 = 1.1 time = 570
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=570.025n

* CHECK dout0_11 Vdout0_11ck113 = 1.1 time = 570
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=570.025n

* CHECK dout0_12 Vdout0_12ck113 = 0 time = 570
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=570.025n

* CHECK dout0_13 Vdout0_13ck113 = 0 time = 570
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=570.025n

* CHECK dout0_14 Vdout0_14ck113 = 0 time = 570
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=570.025n

* CHECK dout0_15 Vdout0_15ck113 = 1.1 time = 570
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=570.025n

* CHECK dout0_16 Vdout0_16ck113 = 1.1 time = 570
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=570.025n

* CHECK dout0_17 Vdout0_17ck113 = 0 time = 570
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=570.025n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 570
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=570.025n

* CHECK dout0_19 Vdout0_19ck113 = 1.1 time = 570
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=570.025n

* CHECK dout0_20 Vdout0_20ck113 = 0 time = 570
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=570.025n

* CHECK dout0_21 Vdout0_21ck113 = 0 time = 570
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=570.025n

* CHECK dout0_22 Vdout0_22ck113 = 0 time = 570
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=570.025n

* CHECK dout0_23 Vdout0_23ck113 = 0 time = 570
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=570.025n

* CHECK dout0_24 Vdout0_24ck113 = 0 time = 570
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=570.025n

* CHECK dout0_25 Vdout0_25ck113 = 0 time = 570
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=570.025n

* CHECK dout0_26 Vdout0_26ck113 = 0 time = 570
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=570.025n

* CHECK dout0_27 Vdout0_27ck113 = 1.1 time = 570
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=570.025n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 570
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=570.025n

* CHECK dout0_29 Vdout0_29ck113 = 0 time = 570
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=570.025n

* CHECK dout0_30 Vdout0_30ck113 = 1.1 time = 570
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=570.025n

* CHECK dout0_31 Vdout0_31ck113 = 1.1 time = 570
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=570.025n

* CHECK dout0_0 Vdout0_0ck115 = 0 time = 580
.meas tran vdout0_0ck115 FIND v(dout0_0) AT=580.025n

* CHECK dout0_1 Vdout0_1ck115 = 0 time = 580
.meas tran vdout0_1ck115 FIND v(dout0_1) AT=580.025n

* CHECK dout0_2 Vdout0_2ck115 = 1.1 time = 580
.meas tran vdout0_2ck115 FIND v(dout0_2) AT=580.025n

* CHECK dout0_3 Vdout0_3ck115 = 1.1 time = 580
.meas tran vdout0_3ck115 FIND v(dout0_3) AT=580.025n

* CHECK dout0_4 Vdout0_4ck115 = 1.1 time = 580
.meas tran vdout0_4ck115 FIND v(dout0_4) AT=580.025n

* CHECK dout0_5 Vdout0_5ck115 = 1.1 time = 580
.meas tran vdout0_5ck115 FIND v(dout0_5) AT=580.025n

* CHECK dout0_6 Vdout0_6ck115 = 1.1 time = 580
.meas tran vdout0_6ck115 FIND v(dout0_6) AT=580.025n

* CHECK dout0_7 Vdout0_7ck115 = 1.1 time = 580
.meas tran vdout0_7ck115 FIND v(dout0_7) AT=580.025n

* CHECK dout0_8 Vdout0_8ck115 = 1.1 time = 580
.meas tran vdout0_8ck115 FIND v(dout0_8) AT=580.025n

* CHECK dout0_9 Vdout0_9ck115 = 1.1 time = 580
.meas tran vdout0_9ck115 FIND v(dout0_9) AT=580.025n

* CHECK dout0_10 Vdout0_10ck115 = 0 time = 580
.meas tran vdout0_10ck115 FIND v(dout0_10) AT=580.025n

* CHECK dout0_11 Vdout0_11ck115 = 0 time = 580
.meas tran vdout0_11ck115 FIND v(dout0_11) AT=580.025n

* CHECK dout0_12 Vdout0_12ck115 = 0 time = 580
.meas tran vdout0_12ck115 FIND v(dout0_12) AT=580.025n

* CHECK dout0_13 Vdout0_13ck115 = 1.1 time = 580
.meas tran vdout0_13ck115 FIND v(dout0_13) AT=580.025n

* CHECK dout0_14 Vdout0_14ck115 = 0 time = 580
.meas tran vdout0_14ck115 FIND v(dout0_14) AT=580.025n

* CHECK dout0_15 Vdout0_15ck115 = 0 time = 580
.meas tran vdout0_15ck115 FIND v(dout0_15) AT=580.025n

* CHECK dout0_16 Vdout0_16ck115 = 1.1 time = 580
.meas tran vdout0_16ck115 FIND v(dout0_16) AT=580.025n

* CHECK dout0_17 Vdout0_17ck115 = 0 time = 580
.meas tran vdout0_17ck115 FIND v(dout0_17) AT=580.025n

* CHECK dout0_18 Vdout0_18ck115 = 1.1 time = 580
.meas tran vdout0_18ck115 FIND v(dout0_18) AT=580.025n

* CHECK dout0_19 Vdout0_19ck115 = 0 time = 580
.meas tran vdout0_19ck115 FIND v(dout0_19) AT=580.025n

* CHECK dout0_20 Vdout0_20ck115 = 1.1 time = 580
.meas tran vdout0_20ck115 FIND v(dout0_20) AT=580.025n

* CHECK dout0_21 Vdout0_21ck115 = 0 time = 580
.meas tran vdout0_21ck115 FIND v(dout0_21) AT=580.025n

* CHECK dout0_22 Vdout0_22ck115 = 1.1 time = 580
.meas tran vdout0_22ck115 FIND v(dout0_22) AT=580.025n

* CHECK dout0_23 Vdout0_23ck115 = 0 time = 580
.meas tran vdout0_23ck115 FIND v(dout0_23) AT=580.025n

* CHECK dout0_24 Vdout0_24ck115 = 0 time = 580
.meas tran vdout0_24ck115 FIND v(dout0_24) AT=580.025n

* CHECK dout0_25 Vdout0_25ck115 = 0 time = 580
.meas tran vdout0_25ck115 FIND v(dout0_25) AT=580.025n

* CHECK dout0_26 Vdout0_26ck115 = 1.1 time = 580
.meas tran vdout0_26ck115 FIND v(dout0_26) AT=580.025n

* CHECK dout0_27 Vdout0_27ck115 = 1.1 time = 580
.meas tran vdout0_27ck115 FIND v(dout0_27) AT=580.025n

* CHECK dout0_28 Vdout0_28ck115 = 0 time = 580
.meas tran vdout0_28ck115 FIND v(dout0_28) AT=580.025n

* CHECK dout0_29 Vdout0_29ck115 = 0 time = 580
.meas tran vdout0_29ck115 FIND v(dout0_29) AT=580.025n

* CHECK dout0_30 Vdout0_30ck115 = 1.1 time = 580
.meas tran vdout0_30ck115 FIND v(dout0_30) AT=580.025n

* CHECK dout0_31 Vdout0_31ck115 = 1.1 time = 580
.meas tran vdout0_31ck115 FIND v(dout0_31) AT=580.025n

* CHECK dout0_0 Vdout0_0ck117 = 0 time = 590
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=590.025n

* CHECK dout0_1 Vdout0_1ck117 = 0 time = 590
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=590.025n

* CHECK dout0_2 Vdout0_2ck117 = 0 time = 590
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=590.025n

* CHECK dout0_3 Vdout0_3ck117 = 0 time = 590
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=590.025n

* CHECK dout0_4 Vdout0_4ck117 = 0 time = 590
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=590.025n

* CHECK dout0_5 Vdout0_5ck117 = 0 time = 590
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=590.025n

* CHECK dout0_6 Vdout0_6ck117 = 0 time = 590
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=590.025n

* CHECK dout0_7 Vdout0_7ck117 = 0 time = 590
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=590.025n

* CHECK dout0_8 Vdout0_8ck117 = 0 time = 590
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=590.025n

* CHECK dout0_9 Vdout0_9ck117 = 1.1 time = 590
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=590.025n

* CHECK dout0_10 Vdout0_10ck117 = 1.1 time = 590
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=590.025n

* CHECK dout0_11 Vdout0_11ck117 = 1.1 time = 590
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=590.025n

* CHECK dout0_12 Vdout0_12ck117 = 0 time = 590
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=590.025n

* CHECK dout0_13 Vdout0_13ck117 = 0 time = 590
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=590.025n

* CHECK dout0_14 Vdout0_14ck117 = 0 time = 590
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=590.025n

* CHECK dout0_15 Vdout0_15ck117 = 1.1 time = 590
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=590.025n

* CHECK dout0_16 Vdout0_16ck117 = 1.1 time = 590
.meas tran vdout0_16ck117 FIND v(dout0_16) AT=590.025n

* CHECK dout0_17 Vdout0_17ck117 = 0 time = 590
.meas tran vdout0_17ck117 FIND v(dout0_17) AT=590.025n

* CHECK dout0_18 Vdout0_18ck117 = 0 time = 590
.meas tran vdout0_18ck117 FIND v(dout0_18) AT=590.025n

* CHECK dout0_19 Vdout0_19ck117 = 1.1 time = 590
.meas tran vdout0_19ck117 FIND v(dout0_19) AT=590.025n

* CHECK dout0_20 Vdout0_20ck117 = 0 time = 590
.meas tran vdout0_20ck117 FIND v(dout0_20) AT=590.025n

* CHECK dout0_21 Vdout0_21ck117 = 0 time = 590
.meas tran vdout0_21ck117 FIND v(dout0_21) AT=590.025n

* CHECK dout0_22 Vdout0_22ck117 = 0 time = 590
.meas tran vdout0_22ck117 FIND v(dout0_22) AT=590.025n

* CHECK dout0_23 Vdout0_23ck117 = 0 time = 590
.meas tran vdout0_23ck117 FIND v(dout0_23) AT=590.025n

* CHECK dout0_24 Vdout0_24ck117 = 0 time = 590
.meas tran vdout0_24ck117 FIND v(dout0_24) AT=590.025n

* CHECK dout0_25 Vdout0_25ck117 = 0 time = 590
.meas tran vdout0_25ck117 FIND v(dout0_25) AT=590.025n

* CHECK dout0_26 Vdout0_26ck117 = 0 time = 590
.meas tran vdout0_26ck117 FIND v(dout0_26) AT=590.025n

* CHECK dout0_27 Vdout0_27ck117 = 1.1 time = 590
.meas tran vdout0_27ck117 FIND v(dout0_27) AT=590.025n

* CHECK dout0_28 Vdout0_28ck117 = 0 time = 590
.meas tran vdout0_28ck117 FIND v(dout0_28) AT=590.025n

* CHECK dout0_29 Vdout0_29ck117 = 0 time = 590
.meas tran vdout0_29ck117 FIND v(dout0_29) AT=590.025n

* CHECK dout0_30 Vdout0_30ck117 = 1.1 time = 590
.meas tran vdout0_30ck117 FIND v(dout0_30) AT=590.025n

* CHECK dout0_31 Vdout0_31ck117 = 1.1 time = 590
.meas tran vdout0_31ck117 FIND v(dout0_31) AT=590.025n

* CHECK dout0_0 Vdout0_0ck119 = 0 time = 600
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=600.025n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 600
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=600.025n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 600
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=600.025n

* CHECK dout0_3 Vdout0_3ck119 = 0 time = 600
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=600.025n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 600
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=600.025n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 600
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=600.025n

* CHECK dout0_6 Vdout0_6ck119 = 0 time = 600
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=600.025n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 600
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=600.025n

* CHECK dout0_8 Vdout0_8ck119 = 0 time = 600
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=600.025n

* CHECK dout0_9 Vdout0_9ck119 = 1.1 time = 600
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=600.025n

* CHECK dout0_10 Vdout0_10ck119 = 1.1 time = 600
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=600.025n

* CHECK dout0_11 Vdout0_11ck119 = 1.1 time = 600
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=600.025n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 600
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=600.025n

* CHECK dout0_13 Vdout0_13ck119 = 0 time = 600
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=600.025n

* CHECK dout0_14 Vdout0_14ck119 = 0 time = 600
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=600.025n

* CHECK dout0_15 Vdout0_15ck119 = 1.1 time = 600
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=600.025n

* CHECK dout0_16 Vdout0_16ck119 = 1.1 time = 600
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=600.025n

* CHECK dout0_17 Vdout0_17ck119 = 0 time = 600
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=600.025n

* CHECK dout0_18 Vdout0_18ck119 = 0 time = 600
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=600.025n

* CHECK dout0_19 Vdout0_19ck119 = 1.1 time = 600
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=600.025n

* CHECK dout0_20 Vdout0_20ck119 = 0 time = 600
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=600.025n

* CHECK dout0_21 Vdout0_21ck119 = 0 time = 600
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=600.025n

* CHECK dout0_22 Vdout0_22ck119 = 0 time = 600
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=600.025n

* CHECK dout0_23 Vdout0_23ck119 = 0 time = 600
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=600.025n

* CHECK dout0_24 Vdout0_24ck119 = 0 time = 600
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=600.025n

* CHECK dout0_25 Vdout0_25ck119 = 0 time = 600
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=600.025n

* CHECK dout0_26 Vdout0_26ck119 = 0 time = 600
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=600.025n

* CHECK dout0_27 Vdout0_27ck119 = 1.1 time = 600
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=600.025n

* CHECK dout0_28 Vdout0_28ck119 = 0 time = 600
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=600.025n

* CHECK dout0_29 Vdout0_29ck119 = 0 time = 600
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=600.025n

* CHECK dout0_30 Vdout0_30ck119 = 1.1 time = 600
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=600.025n

* CHECK dout0_31 Vdout0_31ck119 = 1.1 time = 600
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=600.025n

* CHECK dout0_0 Vdout0_0ck120 = 1.1 time = 605
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=605.025n

* CHECK dout0_1 Vdout0_1ck120 = 0 time = 605
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=605.025n

* CHECK dout0_2 Vdout0_2ck120 = 1.1 time = 605
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=605.025n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 605
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=605.025n

* CHECK dout0_4 Vdout0_4ck120 = 1.1 time = 605
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=605.025n

* CHECK dout0_5 Vdout0_5ck120 = 1.1 time = 605
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=605.025n

* CHECK dout0_6 Vdout0_6ck120 = 0 time = 605
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=605.025n

* CHECK dout0_7 Vdout0_7ck120 = 1.1 time = 605
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=605.025n

* CHECK dout0_8 Vdout0_8ck120 = 1.1 time = 605
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=605.025n

* CHECK dout0_9 Vdout0_9ck120 = 1.1 time = 605
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=605.025n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 605
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=605.025n

* CHECK dout0_11 Vdout0_11ck120 = 0 time = 605
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=605.025n

* CHECK dout0_12 Vdout0_12ck120 = 0 time = 605
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=605.025n

* CHECK dout0_13 Vdout0_13ck120 = 1.1 time = 605
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=605.025n

* CHECK dout0_14 Vdout0_14ck120 = 1.1 time = 605
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=605.025n

* CHECK dout0_15 Vdout0_15ck120 = 1.1 time = 605
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=605.025n

* CHECK dout0_16 Vdout0_16ck120 = 1.1 time = 605
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=605.025n

* CHECK dout0_17 Vdout0_17ck120 = 1.1 time = 605
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=605.025n

* CHECK dout0_18 Vdout0_18ck120 = 0 time = 605
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=605.025n

* CHECK dout0_19 Vdout0_19ck120 = 0 time = 605
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=605.025n

* CHECK dout0_20 Vdout0_20ck120 = 0 time = 605
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=605.025n

* CHECK dout0_21 Vdout0_21ck120 = 0 time = 605
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=605.025n

* CHECK dout0_22 Vdout0_22ck120 = 0 time = 605
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=605.025n

* CHECK dout0_23 Vdout0_23ck120 = 0 time = 605
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=605.025n

* CHECK dout0_24 Vdout0_24ck120 = 0 time = 605
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=605.025n

* CHECK dout0_25 Vdout0_25ck120 = 0 time = 605
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=605.025n

* CHECK dout0_26 Vdout0_26ck120 = 0 time = 605
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=605.025n

* CHECK dout0_27 Vdout0_27ck120 = 1.1 time = 605
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=605.025n

* CHECK dout0_28 Vdout0_28ck120 = 1.1 time = 605
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=605.025n

* CHECK dout0_29 Vdout0_29ck120 = 0 time = 605
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=605.025n

* CHECK dout0_30 Vdout0_30ck120 = 0 time = 605
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=605.025n

* CHECK dout0_31 Vdout0_31ck120 = 1.1 time = 605
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=605.025n

* CHECK dout0_0 Vdout0_0ck121 = 0 time = 610
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=610.025n

* CHECK dout0_1 Vdout0_1ck121 = 1.1 time = 610
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=610.025n

* CHECK dout0_2 Vdout0_2ck121 = 1.1 time = 610
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=610.025n

* CHECK dout0_3 Vdout0_3ck121 = 1.1 time = 610
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=610.025n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 610
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=610.025n

* CHECK dout0_5 Vdout0_5ck121 = 0 time = 610
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=610.025n

* CHECK dout0_6 Vdout0_6ck121 = 0 time = 610
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=610.025n

* CHECK dout0_7 Vdout0_7ck121 = 1.1 time = 610
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=610.025n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 610
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=610.025n

* CHECK dout0_9 Vdout0_9ck121 = 1.1 time = 610
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=610.025n

* CHECK dout0_10 Vdout0_10ck121 = 1.1 time = 610
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=610.025n

* CHECK dout0_11 Vdout0_11ck121 = 1.1 time = 610
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=610.025n

* CHECK dout0_12 Vdout0_12ck121 = 1.1 time = 610
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=610.025n

* CHECK dout0_13 Vdout0_13ck121 = 0 time = 610
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=610.025n

* CHECK dout0_14 Vdout0_14ck121 = 1.1 time = 610
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=610.025n

* CHECK dout0_15 Vdout0_15ck121 = 1.1 time = 610
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=610.025n

* CHECK dout0_16 Vdout0_16ck121 = 0 time = 610
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=610.025n

* CHECK dout0_17 Vdout0_17ck121 = 0 time = 610
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=610.025n

* CHECK dout0_18 Vdout0_18ck121 = 1.1 time = 610
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=610.025n

* CHECK dout0_19 Vdout0_19ck121 = 0 time = 610
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=610.025n

* CHECK dout0_20 Vdout0_20ck121 = 1.1 time = 610
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=610.025n

* CHECK dout0_21 Vdout0_21ck121 = 0 time = 610
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=610.025n

* CHECK dout0_22 Vdout0_22ck121 = 0 time = 610
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=610.025n

* CHECK dout0_23 Vdout0_23ck121 = 0 time = 610
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=610.025n

* CHECK dout0_24 Vdout0_24ck121 = 0 time = 610
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=610.025n

* CHECK dout0_25 Vdout0_25ck121 = 1.1 time = 610
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=610.025n

* CHECK dout0_26 Vdout0_26ck121 = 1.1 time = 610
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=610.025n

* CHECK dout0_27 Vdout0_27ck121 = 1.1 time = 610
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=610.025n

* CHECK dout0_28 Vdout0_28ck121 = 1.1 time = 610
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=610.025n

* CHECK dout0_29 Vdout0_29ck121 = 0 time = 610
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=610.025n

* CHECK dout0_30 Vdout0_30ck121 = 1.1 time = 610
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=610.025n

* CHECK dout0_31 Vdout0_31ck121 = 0 time = 610
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=610.025n

* CHECK dout0_0 Vdout0_0ck122 = 1.1 time = 615
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=615.025n

* CHECK dout0_1 Vdout0_1ck122 = 0 time = 615
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=615.025n

* CHECK dout0_2 Vdout0_2ck122 = 1.1 time = 615
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=615.025n

* CHECK dout0_3 Vdout0_3ck122 = 1.1 time = 615
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=615.025n

* CHECK dout0_4 Vdout0_4ck122 = 1.1 time = 615
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=615.025n

* CHECK dout0_5 Vdout0_5ck122 = 1.1 time = 615
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=615.025n

* CHECK dout0_6 Vdout0_6ck122 = 1.1 time = 615
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=615.025n

* CHECK dout0_7 Vdout0_7ck122 = 1.1 time = 615
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=615.025n

* CHECK dout0_8 Vdout0_8ck122 = 1.1 time = 615
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=615.025n

* CHECK dout0_9 Vdout0_9ck122 = 1.1 time = 615
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=615.025n

* CHECK dout0_10 Vdout0_10ck122 = 1.1 time = 615
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=615.025n

* CHECK dout0_11 Vdout0_11ck122 = 0 time = 615
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=615.025n

* CHECK dout0_12 Vdout0_12ck122 = 0 time = 615
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=615.025n

* CHECK dout0_13 Vdout0_13ck122 = 1.1 time = 615
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=615.025n

* CHECK dout0_14 Vdout0_14ck122 = 1.1 time = 615
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=615.025n

* CHECK dout0_15 Vdout0_15ck122 = 1.1 time = 615
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=615.025n

* CHECK dout0_16 Vdout0_16ck122 = 1.1 time = 615
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=615.025n

* CHECK dout0_17 Vdout0_17ck122 = 0 time = 615
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=615.025n

* CHECK dout0_18 Vdout0_18ck122 = 1.1 time = 615
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=615.025n

* CHECK dout0_19 Vdout0_19ck122 = 0 time = 615
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=615.025n

* CHECK dout0_20 Vdout0_20ck122 = 1.1 time = 615
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=615.025n

* CHECK dout0_21 Vdout0_21ck122 = 1.1 time = 615
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=615.025n

* CHECK dout0_22 Vdout0_22ck122 = 0 time = 615
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=615.025n

* CHECK dout0_23 Vdout0_23ck122 = 0 time = 615
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=615.025n

* CHECK dout0_24 Vdout0_24ck122 = 0 time = 615
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=615.025n

* CHECK dout0_25 Vdout0_25ck122 = 0 time = 615
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=615.025n

* CHECK dout0_26 Vdout0_26ck122 = 0 time = 615
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=615.025n

* CHECK dout0_27 Vdout0_27ck122 = 1.1 time = 615
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=615.025n

* CHECK dout0_28 Vdout0_28ck122 = 0 time = 615
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=615.025n

* CHECK dout0_29 Vdout0_29ck122 = 0 time = 615
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=615.025n

* CHECK dout0_30 Vdout0_30ck122 = 1.1 time = 615
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=615.025n

* CHECK dout0_31 Vdout0_31ck122 = 1.1 time = 615
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=615.025n

* CHECK dout0_0 Vdout0_0ck123 = 1.1 time = 620
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=620.025n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 620
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=620.025n

* CHECK dout0_2 Vdout0_2ck123 = 1.1 time = 620
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=620.025n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 620
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=620.025n

* CHECK dout0_4 Vdout0_4ck123 = 1.1 time = 620
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=620.025n

* CHECK dout0_5 Vdout0_5ck123 = 1.1 time = 620
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=620.025n

* CHECK dout0_6 Vdout0_6ck123 = 0 time = 620
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=620.025n

* CHECK dout0_7 Vdout0_7ck123 = 1.1 time = 620
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=620.025n

* CHECK dout0_8 Vdout0_8ck123 = 1.1 time = 620
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=620.025n

* CHECK dout0_9 Vdout0_9ck123 = 1.1 time = 620
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=620.025n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 620
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=620.025n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 620
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=620.025n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 620
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=620.025n

* CHECK dout0_13 Vdout0_13ck123 = 1.1 time = 620
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=620.025n

* CHECK dout0_14 Vdout0_14ck123 = 1.1 time = 620
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=620.025n

* CHECK dout0_15 Vdout0_15ck123 = 1.1 time = 620
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=620.025n

* CHECK dout0_16 Vdout0_16ck123 = 1.1 time = 620
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=620.025n

* CHECK dout0_17 Vdout0_17ck123 = 1.1 time = 620
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=620.025n

* CHECK dout0_18 Vdout0_18ck123 = 0 time = 620
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=620.025n

* CHECK dout0_19 Vdout0_19ck123 = 0 time = 620
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=620.025n

* CHECK dout0_20 Vdout0_20ck123 = 0 time = 620
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=620.025n

* CHECK dout0_21 Vdout0_21ck123 = 0 time = 620
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=620.025n

* CHECK dout0_22 Vdout0_22ck123 = 0 time = 620
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=620.025n

* CHECK dout0_23 Vdout0_23ck123 = 0 time = 620
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=620.025n

* CHECK dout0_24 Vdout0_24ck123 = 0 time = 620
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=620.025n

* CHECK dout0_25 Vdout0_25ck123 = 0 time = 620
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=620.025n

* CHECK dout0_26 Vdout0_26ck123 = 0 time = 620
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=620.025n

* CHECK dout0_27 Vdout0_27ck123 = 1.1 time = 620
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=620.025n

* CHECK dout0_28 Vdout0_28ck123 = 1.1 time = 620
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=620.025n

* CHECK dout0_29 Vdout0_29ck123 = 0 time = 620
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=620.025n

* CHECK dout0_30 Vdout0_30ck123 = 0 time = 620
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=620.025n

* CHECK dout0_31 Vdout0_31ck123 = 1.1 time = 620
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=620.025n

* CHECK dout0_0 Vdout0_0ck127 = 0 time = 640
.meas tran vdout0_0ck127 FIND v(dout0_0) AT=640.025n

* CHECK dout0_1 Vdout0_1ck127 = 1.1 time = 640
.meas tran vdout0_1ck127 FIND v(dout0_1) AT=640.025n

* CHECK dout0_2 Vdout0_2ck127 = 0 time = 640
.meas tran vdout0_2ck127 FIND v(dout0_2) AT=640.025n

* CHECK dout0_3 Vdout0_3ck127 = 1.1 time = 640
.meas tran vdout0_3ck127 FIND v(dout0_3) AT=640.025n

* CHECK dout0_4 Vdout0_4ck127 = 1.1 time = 640
.meas tran vdout0_4ck127 FIND v(dout0_4) AT=640.025n

* CHECK dout0_5 Vdout0_5ck127 = 1.1 time = 640
.meas tran vdout0_5ck127 FIND v(dout0_5) AT=640.025n

* CHECK dout0_6 Vdout0_6ck127 = 1.1 time = 640
.meas tran vdout0_6ck127 FIND v(dout0_6) AT=640.025n

* CHECK dout0_7 Vdout0_7ck127 = 0 time = 640
.meas tran vdout0_7ck127 FIND v(dout0_7) AT=640.025n

* CHECK dout0_8 Vdout0_8ck127 = 1.1 time = 640
.meas tran vdout0_8ck127 FIND v(dout0_8) AT=640.025n

* CHECK dout0_9 Vdout0_9ck127 = 1.1 time = 640
.meas tran vdout0_9ck127 FIND v(dout0_9) AT=640.025n

* CHECK dout0_10 Vdout0_10ck127 = 0 time = 640
.meas tran vdout0_10ck127 FIND v(dout0_10) AT=640.025n

* CHECK dout0_11 Vdout0_11ck127 = 1.1 time = 640
.meas tran vdout0_11ck127 FIND v(dout0_11) AT=640.025n

* CHECK dout0_12 Vdout0_12ck127 = 0 time = 640
.meas tran vdout0_12ck127 FIND v(dout0_12) AT=640.025n

* CHECK dout0_13 Vdout0_13ck127 = 1.1 time = 640
.meas tran vdout0_13ck127 FIND v(dout0_13) AT=640.025n

* CHECK dout0_14 Vdout0_14ck127 = 0 time = 640
.meas tran vdout0_14ck127 FIND v(dout0_14) AT=640.025n

* CHECK dout0_15 Vdout0_15ck127 = 0 time = 640
.meas tran vdout0_15ck127 FIND v(dout0_15) AT=640.025n

* CHECK dout0_16 Vdout0_16ck127 = 1.1 time = 640
.meas tran vdout0_16ck127 FIND v(dout0_16) AT=640.025n

* CHECK dout0_17 Vdout0_17ck127 = 0 time = 640
.meas tran vdout0_17ck127 FIND v(dout0_17) AT=640.025n

* CHECK dout0_18 Vdout0_18ck127 = 0 time = 640
.meas tran vdout0_18ck127 FIND v(dout0_18) AT=640.025n

* CHECK dout0_19 Vdout0_19ck127 = 1.1 time = 640
.meas tran vdout0_19ck127 FIND v(dout0_19) AT=640.025n

* CHECK dout0_20 Vdout0_20ck127 = 0 time = 640
.meas tran vdout0_20ck127 FIND v(dout0_20) AT=640.025n

* CHECK dout0_21 Vdout0_21ck127 = 0 time = 640
.meas tran vdout0_21ck127 FIND v(dout0_21) AT=640.025n

* CHECK dout0_22 Vdout0_22ck127 = 0 time = 640
.meas tran vdout0_22ck127 FIND v(dout0_22) AT=640.025n

* CHECK dout0_23 Vdout0_23ck127 = 0 time = 640
.meas tran vdout0_23ck127 FIND v(dout0_23) AT=640.025n

* CHECK dout0_24 Vdout0_24ck127 = 0 time = 640
.meas tran vdout0_24ck127 FIND v(dout0_24) AT=640.025n

* CHECK dout0_25 Vdout0_25ck127 = 1.1 time = 640
.meas tran vdout0_25ck127 FIND v(dout0_25) AT=640.025n

* CHECK dout0_26 Vdout0_26ck127 = 1.1 time = 640
.meas tran vdout0_26ck127 FIND v(dout0_26) AT=640.025n

* CHECK dout0_27 Vdout0_27ck127 = 1.1 time = 640
.meas tran vdout0_27ck127 FIND v(dout0_27) AT=640.025n

* CHECK dout0_28 Vdout0_28ck127 = 0 time = 640
.meas tran vdout0_28ck127 FIND v(dout0_28) AT=640.025n

* CHECK dout0_29 Vdout0_29ck127 = 0 time = 640
.meas tran vdout0_29ck127 FIND v(dout0_29) AT=640.025n

* CHECK dout0_30 Vdout0_30ck127 = 1.1 time = 640
.meas tran vdout0_30ck127 FIND v(dout0_30) AT=640.025n

* CHECK dout0_31 Vdout0_31ck127 = 0 time = 640
.meas tran vdout0_31ck127 FIND v(dout0_31) AT=640.025n

* CHECK dout0_0 Vdout0_0ck128 = 0 time = 645
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=645.025n

* CHECK dout0_1 Vdout0_1ck128 = 0 time = 645
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=645.025n

* CHECK dout0_2 Vdout0_2ck128 = 0 time = 645
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=645.025n

* CHECK dout0_3 Vdout0_3ck128 = 0 time = 645
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=645.025n

* CHECK dout0_4 Vdout0_4ck128 = 0 time = 645
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=645.025n

* CHECK dout0_5 Vdout0_5ck128 = 0 time = 645
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=645.025n

* CHECK dout0_6 Vdout0_6ck128 = 0 time = 645
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=645.025n

* CHECK dout0_7 Vdout0_7ck128 = 0 time = 645
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=645.025n

* CHECK dout0_8 Vdout0_8ck128 = 0 time = 645
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=645.025n

* CHECK dout0_9 Vdout0_9ck128 = 1.1 time = 645
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=645.025n

* CHECK dout0_10 Vdout0_10ck128 = 1.1 time = 645
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=645.025n

* CHECK dout0_11 Vdout0_11ck128 = 1.1 time = 645
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=645.025n

* CHECK dout0_12 Vdout0_12ck128 = 0 time = 645
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=645.025n

* CHECK dout0_13 Vdout0_13ck128 = 0 time = 645
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=645.025n

* CHECK dout0_14 Vdout0_14ck128 = 0 time = 645
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=645.025n

* CHECK dout0_15 Vdout0_15ck128 = 1.1 time = 645
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=645.025n

* CHECK dout0_16 Vdout0_16ck128 = 1.1 time = 645
.meas tran vdout0_16ck128 FIND v(dout0_16) AT=645.025n

* CHECK dout0_17 Vdout0_17ck128 = 0 time = 645
.meas tran vdout0_17ck128 FIND v(dout0_17) AT=645.025n

* CHECK dout0_18 Vdout0_18ck128 = 0 time = 645
.meas tran vdout0_18ck128 FIND v(dout0_18) AT=645.025n

* CHECK dout0_19 Vdout0_19ck128 = 1.1 time = 645
.meas tran vdout0_19ck128 FIND v(dout0_19) AT=645.025n

* CHECK dout0_20 Vdout0_20ck128 = 0 time = 645
.meas tran vdout0_20ck128 FIND v(dout0_20) AT=645.025n

* CHECK dout0_21 Vdout0_21ck128 = 0 time = 645
.meas tran vdout0_21ck128 FIND v(dout0_21) AT=645.025n

* CHECK dout0_22 Vdout0_22ck128 = 0 time = 645
.meas tran vdout0_22ck128 FIND v(dout0_22) AT=645.025n

* CHECK dout0_23 Vdout0_23ck128 = 0 time = 645
.meas tran vdout0_23ck128 FIND v(dout0_23) AT=645.025n

* CHECK dout0_24 Vdout0_24ck128 = 0 time = 645
.meas tran vdout0_24ck128 FIND v(dout0_24) AT=645.025n

* CHECK dout0_25 Vdout0_25ck128 = 0 time = 645
.meas tran vdout0_25ck128 FIND v(dout0_25) AT=645.025n

* CHECK dout0_26 Vdout0_26ck128 = 0 time = 645
.meas tran vdout0_26ck128 FIND v(dout0_26) AT=645.025n

* CHECK dout0_27 Vdout0_27ck128 = 1.1 time = 645
.meas tran vdout0_27ck128 FIND v(dout0_27) AT=645.025n

* CHECK dout0_28 Vdout0_28ck128 = 0 time = 645
.meas tran vdout0_28ck128 FIND v(dout0_28) AT=645.025n

* CHECK dout0_29 Vdout0_29ck128 = 0 time = 645
.meas tran vdout0_29ck128 FIND v(dout0_29) AT=645.025n

* CHECK dout0_30 Vdout0_30ck128 = 1.1 time = 645
.meas tran vdout0_30ck128 FIND v(dout0_30) AT=645.025n

* CHECK dout0_31 Vdout0_31ck128 = 1.1 time = 645
.meas tran vdout0_31ck128 FIND v(dout0_31) AT=645.025n

* CHECK dout0_0 Vdout0_0ck129 = 1.1 time = 650
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=650.025n

* CHECK dout0_1 Vdout0_1ck129 = 0 time = 650
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=650.025n

* CHECK dout0_2 Vdout0_2ck129 = 1.1 time = 650
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=650.025n

* CHECK dout0_3 Vdout0_3ck129 = 0 time = 650
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=650.025n

* CHECK dout0_4 Vdout0_4ck129 = 1.1 time = 650
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=650.025n

* CHECK dout0_5 Vdout0_5ck129 = 1.1 time = 650
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=650.025n

* CHECK dout0_6 Vdout0_6ck129 = 0 time = 650
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=650.025n

* CHECK dout0_7 Vdout0_7ck129 = 1.1 time = 650
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=650.025n

* CHECK dout0_8 Vdout0_8ck129 = 1.1 time = 650
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=650.025n

* CHECK dout0_9 Vdout0_9ck129 = 1.1 time = 650
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=650.025n

* CHECK dout0_10 Vdout0_10ck129 = 0 time = 650
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=650.025n

* CHECK dout0_11 Vdout0_11ck129 = 0 time = 650
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=650.025n

* CHECK dout0_12 Vdout0_12ck129 = 0 time = 650
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=650.025n

* CHECK dout0_13 Vdout0_13ck129 = 1.1 time = 650
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=650.025n

* CHECK dout0_14 Vdout0_14ck129 = 1.1 time = 650
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=650.025n

* CHECK dout0_15 Vdout0_15ck129 = 1.1 time = 650
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=650.025n

* CHECK dout0_16 Vdout0_16ck129 = 1.1 time = 650
.meas tran vdout0_16ck129 FIND v(dout0_16) AT=650.025n

* CHECK dout0_17 Vdout0_17ck129 = 1.1 time = 650
.meas tran vdout0_17ck129 FIND v(dout0_17) AT=650.025n

* CHECK dout0_18 Vdout0_18ck129 = 0 time = 650
.meas tran vdout0_18ck129 FIND v(dout0_18) AT=650.025n

* CHECK dout0_19 Vdout0_19ck129 = 0 time = 650
.meas tran vdout0_19ck129 FIND v(dout0_19) AT=650.025n

* CHECK dout0_20 Vdout0_20ck129 = 0 time = 650
.meas tran vdout0_20ck129 FIND v(dout0_20) AT=650.025n

* CHECK dout0_21 Vdout0_21ck129 = 0 time = 650
.meas tran vdout0_21ck129 FIND v(dout0_21) AT=650.025n

* CHECK dout0_22 Vdout0_22ck129 = 0 time = 650
.meas tran vdout0_22ck129 FIND v(dout0_22) AT=650.025n

* CHECK dout0_23 Vdout0_23ck129 = 0 time = 650
.meas tran vdout0_23ck129 FIND v(dout0_23) AT=650.025n

* CHECK dout0_24 Vdout0_24ck129 = 0 time = 650
.meas tran vdout0_24ck129 FIND v(dout0_24) AT=650.025n

* CHECK dout0_25 Vdout0_25ck129 = 0 time = 650
.meas tran vdout0_25ck129 FIND v(dout0_25) AT=650.025n

* CHECK dout0_26 Vdout0_26ck129 = 0 time = 650
.meas tran vdout0_26ck129 FIND v(dout0_26) AT=650.025n

* CHECK dout0_27 Vdout0_27ck129 = 1.1 time = 650
.meas tran vdout0_27ck129 FIND v(dout0_27) AT=650.025n

* CHECK dout0_28 Vdout0_28ck129 = 1.1 time = 650
.meas tran vdout0_28ck129 FIND v(dout0_28) AT=650.025n

* CHECK dout0_29 Vdout0_29ck129 = 0 time = 650
.meas tran vdout0_29ck129 FIND v(dout0_29) AT=650.025n

* CHECK dout0_30 Vdout0_30ck129 = 0 time = 650
.meas tran vdout0_30ck129 FIND v(dout0_30) AT=650.025n

* CHECK dout0_31 Vdout0_31ck129 = 1.1 time = 650
.meas tran vdout0_31ck129 FIND v(dout0_31) AT=650.025n

* CHECK dout0_0 Vdout0_0ck131 = 0 time = 660
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=660.025n

* CHECK dout0_1 Vdout0_1ck131 = 1.1 time = 660
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=660.025n

* CHECK dout0_2 Vdout0_2ck131 = 1.1 time = 660
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=660.025n

* CHECK dout0_3 Vdout0_3ck131 = 1.1 time = 660
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=660.025n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 660
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=660.025n

* CHECK dout0_5 Vdout0_5ck131 = 0 time = 660
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=660.025n

* CHECK dout0_6 Vdout0_6ck131 = 0 time = 660
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=660.025n

* CHECK dout0_7 Vdout0_7ck131 = 1.1 time = 660
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=660.025n

* CHECK dout0_8 Vdout0_8ck131 = 0 time = 660
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=660.025n

* CHECK dout0_9 Vdout0_9ck131 = 1.1 time = 660
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=660.025n

* CHECK dout0_10 Vdout0_10ck131 = 1.1 time = 660
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=660.025n

* CHECK dout0_11 Vdout0_11ck131 = 1.1 time = 660
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=660.025n

* CHECK dout0_12 Vdout0_12ck131 = 1.1 time = 660
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=660.025n

* CHECK dout0_13 Vdout0_13ck131 = 0 time = 660
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=660.025n

* CHECK dout0_14 Vdout0_14ck131 = 1.1 time = 660
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=660.025n

* CHECK dout0_15 Vdout0_15ck131 = 1.1 time = 660
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=660.025n

* CHECK dout0_16 Vdout0_16ck131 = 0 time = 660
.meas tran vdout0_16ck131 FIND v(dout0_16) AT=660.025n

* CHECK dout0_17 Vdout0_17ck131 = 0 time = 660
.meas tran vdout0_17ck131 FIND v(dout0_17) AT=660.025n

* CHECK dout0_18 Vdout0_18ck131 = 1.1 time = 660
.meas tran vdout0_18ck131 FIND v(dout0_18) AT=660.025n

* CHECK dout0_19 Vdout0_19ck131 = 0 time = 660
.meas tran vdout0_19ck131 FIND v(dout0_19) AT=660.025n

* CHECK dout0_20 Vdout0_20ck131 = 1.1 time = 660
.meas tran vdout0_20ck131 FIND v(dout0_20) AT=660.025n

* CHECK dout0_21 Vdout0_21ck131 = 0 time = 660
.meas tran vdout0_21ck131 FIND v(dout0_21) AT=660.025n

* CHECK dout0_22 Vdout0_22ck131 = 0 time = 660
.meas tran vdout0_22ck131 FIND v(dout0_22) AT=660.025n

* CHECK dout0_23 Vdout0_23ck131 = 0 time = 660
.meas tran vdout0_23ck131 FIND v(dout0_23) AT=660.025n

* CHECK dout0_24 Vdout0_24ck131 = 0 time = 660
.meas tran vdout0_24ck131 FIND v(dout0_24) AT=660.025n

* CHECK dout0_25 Vdout0_25ck131 = 1.1 time = 660
.meas tran vdout0_25ck131 FIND v(dout0_25) AT=660.025n

* CHECK dout0_26 Vdout0_26ck131 = 1.1 time = 660
.meas tran vdout0_26ck131 FIND v(dout0_26) AT=660.025n

* CHECK dout0_27 Vdout0_27ck131 = 1.1 time = 660
.meas tran vdout0_27ck131 FIND v(dout0_27) AT=660.025n

* CHECK dout0_28 Vdout0_28ck131 = 1.1 time = 660
.meas tran vdout0_28ck131 FIND v(dout0_28) AT=660.025n

* CHECK dout0_29 Vdout0_29ck131 = 0 time = 660
.meas tran vdout0_29ck131 FIND v(dout0_29) AT=660.025n

* CHECK dout0_30 Vdout0_30ck131 = 1.1 time = 660
.meas tran vdout0_30ck131 FIND v(dout0_30) AT=660.025n

* CHECK dout0_31 Vdout0_31ck131 = 0 time = 660
.meas tran vdout0_31ck131 FIND v(dout0_31) AT=660.025n

* CHECK dout0_0 Vdout0_0ck137 = 0 time = 690
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=690.025n

* CHECK dout0_1 Vdout0_1ck137 = 1.1 time = 690
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=690.025n

* CHECK dout0_2 Vdout0_2ck137 = 0 time = 690
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=690.025n

* CHECK dout0_3 Vdout0_3ck137 = 1.1 time = 690
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=690.025n

* CHECK dout0_4 Vdout0_4ck137 = 1.1 time = 690
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=690.025n

* CHECK dout0_5 Vdout0_5ck137 = 1.1 time = 690
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=690.025n

* CHECK dout0_6 Vdout0_6ck137 = 1.1 time = 690
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=690.025n

* CHECK dout0_7 Vdout0_7ck137 = 0 time = 690
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=690.025n

* CHECK dout0_8 Vdout0_8ck137 = 1.1 time = 690
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=690.025n

* CHECK dout0_9 Vdout0_9ck137 = 1.1 time = 690
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=690.025n

* CHECK dout0_10 Vdout0_10ck137 = 0 time = 690
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=690.025n

* CHECK dout0_11 Vdout0_11ck137 = 1.1 time = 690
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=690.025n

* CHECK dout0_12 Vdout0_12ck137 = 0 time = 690
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=690.025n

* CHECK dout0_13 Vdout0_13ck137 = 1.1 time = 690
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=690.025n

* CHECK dout0_14 Vdout0_14ck137 = 0 time = 690
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=690.025n

* CHECK dout0_15 Vdout0_15ck137 = 0 time = 690
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=690.025n

* CHECK dout0_16 Vdout0_16ck137 = 1.1 time = 690
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=690.025n

* CHECK dout0_17 Vdout0_17ck137 = 0 time = 690
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=690.025n

* CHECK dout0_18 Vdout0_18ck137 = 0 time = 690
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=690.025n

* CHECK dout0_19 Vdout0_19ck137 = 1.1 time = 690
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=690.025n

* CHECK dout0_20 Vdout0_20ck137 = 0 time = 690
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=690.025n

* CHECK dout0_21 Vdout0_21ck137 = 0 time = 690
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=690.025n

* CHECK dout0_22 Vdout0_22ck137 = 0 time = 690
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=690.025n

* CHECK dout0_23 Vdout0_23ck137 = 0 time = 690
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=690.025n

* CHECK dout0_24 Vdout0_24ck137 = 0 time = 690
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=690.025n

* CHECK dout0_25 Vdout0_25ck137 = 1.1 time = 690
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=690.025n

* CHECK dout0_26 Vdout0_26ck137 = 1.1 time = 690
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=690.025n

* CHECK dout0_27 Vdout0_27ck137 = 1.1 time = 690
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=690.025n

* CHECK dout0_28 Vdout0_28ck137 = 0 time = 690
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=690.025n

* CHECK dout0_29 Vdout0_29ck137 = 0 time = 690
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=690.025n

* CHECK dout0_30 Vdout0_30ck137 = 1.1 time = 690
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=690.025n

* CHECK dout0_31 Vdout0_31ck137 = 0 time = 690
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=690.025n

* CHECK dout0_0 Vdout0_0ck139 = 0 time = 700
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=700.025n

* CHECK dout0_1 Vdout0_1ck139 = 1.1 time = 700
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=700.025n

* CHECK dout0_2 Vdout0_2ck139 = 0 time = 700
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=700.025n

* CHECK dout0_3 Vdout0_3ck139 = 1.1 time = 700
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=700.025n

* CHECK dout0_4 Vdout0_4ck139 = 1.1 time = 700
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=700.025n

* CHECK dout0_5 Vdout0_5ck139 = 1.1 time = 700
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=700.025n

* CHECK dout0_6 Vdout0_6ck139 = 1.1 time = 700
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=700.025n

* CHECK dout0_7 Vdout0_7ck139 = 0 time = 700
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=700.025n

* CHECK dout0_8 Vdout0_8ck139 = 1.1 time = 700
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=700.025n

* CHECK dout0_9 Vdout0_9ck139 = 1.1 time = 700
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=700.025n

* CHECK dout0_10 Vdout0_10ck139 = 0 time = 700
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=700.025n

* CHECK dout0_11 Vdout0_11ck139 = 1.1 time = 700
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=700.025n

* CHECK dout0_12 Vdout0_12ck139 = 0 time = 700
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=700.025n

* CHECK dout0_13 Vdout0_13ck139 = 1.1 time = 700
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=700.025n

* CHECK dout0_14 Vdout0_14ck139 = 0 time = 700
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=700.025n

* CHECK dout0_15 Vdout0_15ck139 = 0 time = 700
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=700.025n

* CHECK dout0_16 Vdout0_16ck139 = 1.1 time = 700
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=700.025n

* CHECK dout0_17 Vdout0_17ck139 = 0 time = 700
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=700.025n

* CHECK dout0_18 Vdout0_18ck139 = 0 time = 700
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=700.025n

* CHECK dout0_19 Vdout0_19ck139 = 1.1 time = 700
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=700.025n

* CHECK dout0_20 Vdout0_20ck139 = 0 time = 700
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=700.025n

* CHECK dout0_21 Vdout0_21ck139 = 0 time = 700
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=700.025n

* CHECK dout0_22 Vdout0_22ck139 = 0 time = 700
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=700.025n

* CHECK dout0_23 Vdout0_23ck139 = 0 time = 700
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=700.025n

* CHECK dout0_24 Vdout0_24ck139 = 0 time = 700
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=700.025n

* CHECK dout0_25 Vdout0_25ck139 = 1.1 time = 700
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=700.025n

* CHECK dout0_26 Vdout0_26ck139 = 1.1 time = 700
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=700.025n

* CHECK dout0_27 Vdout0_27ck139 = 1.1 time = 700
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=700.025n

* CHECK dout0_28 Vdout0_28ck139 = 0 time = 700
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=700.025n

* CHECK dout0_29 Vdout0_29ck139 = 0 time = 700
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=700.025n

* CHECK dout0_30 Vdout0_30ck139 = 1.1 time = 700
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=700.025n

* CHECK dout0_31 Vdout0_31ck139 = 0 time = 700
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=700.025n

* CHECK dout0_0 Vdout0_0ck140 = 1.1 time = 705
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=705.025n

* CHECK dout0_1 Vdout0_1ck140 = 0 time = 705
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=705.025n

* CHECK dout0_2 Vdout0_2ck140 = 0 time = 705
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=705.025n

* CHECK dout0_3 Vdout0_3ck140 = 1.1 time = 705
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=705.025n

* CHECK dout0_4 Vdout0_4ck140 = 1.1 time = 705
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=705.025n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 705
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=705.025n

* CHECK dout0_6 Vdout0_6ck140 = 1.1 time = 705
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=705.025n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 705
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=705.025n

* CHECK dout0_8 Vdout0_8ck140 = 0 time = 705
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=705.025n

* CHECK dout0_9 Vdout0_9ck140 = 1.1 time = 705
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=705.025n

* CHECK dout0_10 Vdout0_10ck140 = 1.1 time = 705
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=705.025n

* CHECK dout0_11 Vdout0_11ck140 = 1.1 time = 705
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=705.025n

* CHECK dout0_12 Vdout0_12ck140 = 1.1 time = 705
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=705.025n

* CHECK dout0_13 Vdout0_13ck140 = 1.1 time = 705
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=705.025n

* CHECK dout0_14 Vdout0_14ck140 = 1.1 time = 705
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=705.025n

* CHECK dout0_15 Vdout0_15ck140 = 1.1 time = 705
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=705.025n

* CHECK dout0_16 Vdout0_16ck140 = 0 time = 705
.meas tran vdout0_16ck140 FIND v(dout0_16) AT=705.025n

* CHECK dout0_17 Vdout0_17ck140 = 0 time = 705
.meas tran vdout0_17ck140 FIND v(dout0_17) AT=705.025n

* CHECK dout0_18 Vdout0_18ck140 = 0 time = 705
.meas tran vdout0_18ck140 FIND v(dout0_18) AT=705.025n

* CHECK dout0_19 Vdout0_19ck140 = 0 time = 705
.meas tran vdout0_19ck140 FIND v(dout0_19) AT=705.025n

* CHECK dout0_20 Vdout0_20ck140 = 0 time = 705
.meas tran vdout0_20ck140 FIND v(dout0_20) AT=705.025n

* CHECK dout0_21 Vdout0_21ck140 = 1.1 time = 705
.meas tran vdout0_21ck140 FIND v(dout0_21) AT=705.025n

* CHECK dout0_22 Vdout0_22ck140 = 1.1 time = 705
.meas tran vdout0_22ck140 FIND v(dout0_22) AT=705.025n

* CHECK dout0_23 Vdout0_23ck140 = 0 time = 705
.meas tran vdout0_23ck140 FIND v(dout0_23) AT=705.025n

* CHECK dout0_24 Vdout0_24ck140 = 1.1 time = 705
.meas tran vdout0_24ck140 FIND v(dout0_24) AT=705.025n

* CHECK dout0_25 Vdout0_25ck140 = 1.1 time = 705
.meas tran vdout0_25ck140 FIND v(dout0_25) AT=705.025n

* CHECK dout0_26 Vdout0_26ck140 = 1.1 time = 705
.meas tran vdout0_26ck140 FIND v(dout0_26) AT=705.025n

* CHECK dout0_27 Vdout0_27ck140 = 1.1 time = 705
.meas tran vdout0_27ck140 FIND v(dout0_27) AT=705.025n

* CHECK dout0_28 Vdout0_28ck140 = 1.1 time = 705
.meas tran vdout0_28ck140 FIND v(dout0_28) AT=705.025n

* CHECK dout0_29 Vdout0_29ck140 = 1.1 time = 705
.meas tran vdout0_29ck140 FIND v(dout0_29) AT=705.025n

* CHECK dout0_30 Vdout0_30ck140 = 0 time = 705
.meas tran vdout0_30ck140 FIND v(dout0_30) AT=705.025n

* CHECK dout0_31 Vdout0_31ck140 = 1.1 time = 705
.meas tran vdout0_31ck140 FIND v(dout0_31) AT=705.025n

* CHECK dout0_0 Vdout0_0ck141 = 0 time = 710
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=710.025n

* CHECK dout0_1 Vdout0_1ck141 = 1.1 time = 710
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=710.025n

* CHECK dout0_2 Vdout0_2ck141 = 0 time = 710
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=710.025n

* CHECK dout0_3 Vdout0_3ck141 = 1.1 time = 710
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=710.025n

* CHECK dout0_4 Vdout0_4ck141 = 1.1 time = 710
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=710.025n

* CHECK dout0_5 Vdout0_5ck141 = 1.1 time = 710
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=710.025n

* CHECK dout0_6 Vdout0_6ck141 = 0 time = 710
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=710.025n

* CHECK dout0_7 Vdout0_7ck141 = 0 time = 710
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=710.025n

* CHECK dout0_8 Vdout0_8ck141 = 0 time = 710
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=710.025n

* CHECK dout0_9 Vdout0_9ck141 = 0 time = 710
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=710.025n

* CHECK dout0_10 Vdout0_10ck141 = 1.1 time = 710
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=710.025n

* CHECK dout0_11 Vdout0_11ck141 = 1.1 time = 710
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=710.025n

* CHECK dout0_12 Vdout0_12ck141 = 1.1 time = 710
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=710.025n

* CHECK dout0_13 Vdout0_13ck141 = 1.1 time = 710
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=710.025n

* CHECK dout0_14 Vdout0_14ck141 = 0 time = 710
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=710.025n

* CHECK dout0_15 Vdout0_15ck141 = 0 time = 710
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=710.025n

* CHECK dout0_16 Vdout0_16ck141 = 1.1 time = 710
.meas tran vdout0_16ck141 FIND v(dout0_16) AT=710.025n

* CHECK dout0_17 Vdout0_17ck141 = 0 time = 710
.meas tran vdout0_17ck141 FIND v(dout0_17) AT=710.025n

* CHECK dout0_18 Vdout0_18ck141 = 1.1 time = 710
.meas tran vdout0_18ck141 FIND v(dout0_18) AT=710.025n

* CHECK dout0_19 Vdout0_19ck141 = 1.1 time = 710
.meas tran vdout0_19ck141 FIND v(dout0_19) AT=710.025n

* CHECK dout0_20 Vdout0_20ck141 = 1.1 time = 710
.meas tran vdout0_20ck141 FIND v(dout0_20) AT=710.025n

* CHECK dout0_21 Vdout0_21ck141 = 1.1 time = 710
.meas tran vdout0_21ck141 FIND v(dout0_21) AT=710.025n

* CHECK dout0_22 Vdout0_22ck141 = 1.1 time = 710
.meas tran vdout0_22ck141 FIND v(dout0_22) AT=710.025n

* CHECK dout0_23 Vdout0_23ck141 = 0 time = 710
.meas tran vdout0_23ck141 FIND v(dout0_23) AT=710.025n

* CHECK dout0_24 Vdout0_24ck141 = 0 time = 710
.meas tran vdout0_24ck141 FIND v(dout0_24) AT=710.025n

* CHECK dout0_25 Vdout0_25ck141 = 0 time = 710
.meas tran vdout0_25ck141 FIND v(dout0_25) AT=710.025n

* CHECK dout0_26 Vdout0_26ck141 = 0 time = 710
.meas tran vdout0_26ck141 FIND v(dout0_26) AT=710.025n

* CHECK dout0_27 Vdout0_27ck141 = 0 time = 710
.meas tran vdout0_27ck141 FIND v(dout0_27) AT=710.025n

* CHECK dout0_28 Vdout0_28ck141 = 0 time = 710
.meas tran vdout0_28ck141 FIND v(dout0_28) AT=710.025n

* CHECK dout0_29 Vdout0_29ck141 = 1.1 time = 710
.meas tran vdout0_29ck141 FIND v(dout0_29) AT=710.025n

* CHECK dout0_30 Vdout0_30ck141 = 0 time = 710
.meas tran vdout0_30ck141 FIND v(dout0_30) AT=710.025n

* CHECK dout0_31 Vdout0_31ck141 = 1.1 time = 710
.meas tran vdout0_31ck141 FIND v(dout0_31) AT=710.025n

* CHECK dout0_0 Vdout0_0ck143 = 1.1 time = 720
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=720.025n

* CHECK dout0_1 Vdout0_1ck143 = 0 time = 720
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=720.025n

* CHECK dout0_2 Vdout0_2ck143 = 1.1 time = 720
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=720.025n

* CHECK dout0_3 Vdout0_3ck143 = 0 time = 720
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=720.025n

* CHECK dout0_4 Vdout0_4ck143 = 1.1 time = 720
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=720.025n

* CHECK dout0_5 Vdout0_5ck143 = 1.1 time = 720
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=720.025n

* CHECK dout0_6 Vdout0_6ck143 = 0 time = 720
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=720.025n

* CHECK dout0_7 Vdout0_7ck143 = 1.1 time = 720
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=720.025n

* CHECK dout0_8 Vdout0_8ck143 = 1.1 time = 720
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=720.025n

* CHECK dout0_9 Vdout0_9ck143 = 1.1 time = 720
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=720.025n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 720
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=720.025n

* CHECK dout0_11 Vdout0_11ck143 = 0 time = 720
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=720.025n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 720
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=720.025n

* CHECK dout0_13 Vdout0_13ck143 = 1.1 time = 720
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=720.025n

* CHECK dout0_14 Vdout0_14ck143 = 1.1 time = 720
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=720.025n

* CHECK dout0_15 Vdout0_15ck143 = 1.1 time = 720
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=720.025n

* CHECK dout0_16 Vdout0_16ck143 = 1.1 time = 720
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=720.025n

* CHECK dout0_17 Vdout0_17ck143 = 1.1 time = 720
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=720.025n

* CHECK dout0_18 Vdout0_18ck143 = 0 time = 720
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=720.025n

* CHECK dout0_19 Vdout0_19ck143 = 0 time = 720
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=720.025n

* CHECK dout0_20 Vdout0_20ck143 = 0 time = 720
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=720.025n

* CHECK dout0_21 Vdout0_21ck143 = 0 time = 720
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=720.025n

* CHECK dout0_22 Vdout0_22ck143 = 0 time = 720
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=720.025n

* CHECK dout0_23 Vdout0_23ck143 = 0 time = 720
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=720.025n

* CHECK dout0_24 Vdout0_24ck143 = 0 time = 720
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=720.025n

* CHECK dout0_25 Vdout0_25ck143 = 0 time = 720
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=720.025n

* CHECK dout0_26 Vdout0_26ck143 = 0 time = 720
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=720.025n

* CHECK dout0_27 Vdout0_27ck143 = 1.1 time = 720
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=720.025n

* CHECK dout0_28 Vdout0_28ck143 = 1.1 time = 720
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=720.025n

* CHECK dout0_29 Vdout0_29ck143 = 0 time = 720
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=720.025n

* CHECK dout0_30 Vdout0_30ck143 = 0 time = 720
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=720.025n

* CHECK dout0_31 Vdout0_31ck143 = 1.1 time = 720
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=720.025n

* CHECK dout0_0 Vdout0_0ck145 = 1.1 time = 730
.meas tran vdout0_0ck145 FIND v(dout0_0) AT=730.025n

* CHECK dout0_1 Vdout0_1ck145 = 0 time = 730
.meas tran vdout0_1ck145 FIND v(dout0_1) AT=730.025n

* CHECK dout0_2 Vdout0_2ck145 = 0 time = 730
.meas tran vdout0_2ck145 FIND v(dout0_2) AT=730.025n

* CHECK dout0_3 Vdout0_3ck145 = 1.1 time = 730
.meas tran vdout0_3ck145 FIND v(dout0_3) AT=730.025n

* CHECK dout0_4 Vdout0_4ck145 = 1.1 time = 730
.meas tran vdout0_4ck145 FIND v(dout0_4) AT=730.025n

* CHECK dout0_5 Vdout0_5ck145 = 0 time = 730
.meas tran vdout0_5ck145 FIND v(dout0_5) AT=730.025n

* CHECK dout0_6 Vdout0_6ck145 = 1.1 time = 730
.meas tran vdout0_6ck145 FIND v(dout0_6) AT=730.025n

* CHECK dout0_7 Vdout0_7ck145 = 0 time = 730
.meas tran vdout0_7ck145 FIND v(dout0_7) AT=730.025n

* CHECK dout0_8 Vdout0_8ck145 = 0 time = 730
.meas tran vdout0_8ck145 FIND v(dout0_8) AT=730.025n

* CHECK dout0_9 Vdout0_9ck145 = 1.1 time = 730
.meas tran vdout0_9ck145 FIND v(dout0_9) AT=730.025n

* CHECK dout0_10 Vdout0_10ck145 = 1.1 time = 730
.meas tran vdout0_10ck145 FIND v(dout0_10) AT=730.025n

* CHECK dout0_11 Vdout0_11ck145 = 1.1 time = 730
.meas tran vdout0_11ck145 FIND v(dout0_11) AT=730.025n

* CHECK dout0_12 Vdout0_12ck145 = 1.1 time = 730
.meas tran vdout0_12ck145 FIND v(dout0_12) AT=730.025n

* CHECK dout0_13 Vdout0_13ck145 = 1.1 time = 730
.meas tran vdout0_13ck145 FIND v(dout0_13) AT=730.025n

* CHECK dout0_14 Vdout0_14ck145 = 1.1 time = 730
.meas tran vdout0_14ck145 FIND v(dout0_14) AT=730.025n

* CHECK dout0_15 Vdout0_15ck145 = 1.1 time = 730
.meas tran vdout0_15ck145 FIND v(dout0_15) AT=730.025n

* CHECK dout0_16 Vdout0_16ck145 = 0 time = 730
.meas tran vdout0_16ck145 FIND v(dout0_16) AT=730.025n

* CHECK dout0_17 Vdout0_17ck145 = 0 time = 730
.meas tran vdout0_17ck145 FIND v(dout0_17) AT=730.025n

* CHECK dout0_18 Vdout0_18ck145 = 0 time = 730
.meas tran vdout0_18ck145 FIND v(dout0_18) AT=730.025n

* CHECK dout0_19 Vdout0_19ck145 = 0 time = 730
.meas tran vdout0_19ck145 FIND v(dout0_19) AT=730.025n

* CHECK dout0_20 Vdout0_20ck145 = 0 time = 730
.meas tran vdout0_20ck145 FIND v(dout0_20) AT=730.025n

* CHECK dout0_21 Vdout0_21ck145 = 1.1 time = 730
.meas tran vdout0_21ck145 FIND v(dout0_21) AT=730.025n

* CHECK dout0_22 Vdout0_22ck145 = 1.1 time = 730
.meas tran vdout0_22ck145 FIND v(dout0_22) AT=730.025n

* CHECK dout0_23 Vdout0_23ck145 = 0 time = 730
.meas tran vdout0_23ck145 FIND v(dout0_23) AT=730.025n

* CHECK dout0_24 Vdout0_24ck145 = 1.1 time = 730
.meas tran vdout0_24ck145 FIND v(dout0_24) AT=730.025n

* CHECK dout0_25 Vdout0_25ck145 = 1.1 time = 730
.meas tran vdout0_25ck145 FIND v(dout0_25) AT=730.025n

* CHECK dout0_26 Vdout0_26ck145 = 1.1 time = 730
.meas tran vdout0_26ck145 FIND v(dout0_26) AT=730.025n

* CHECK dout0_27 Vdout0_27ck145 = 1.1 time = 730
.meas tran vdout0_27ck145 FIND v(dout0_27) AT=730.025n

* CHECK dout0_28 Vdout0_28ck145 = 1.1 time = 730
.meas tran vdout0_28ck145 FIND v(dout0_28) AT=730.025n

* CHECK dout0_29 Vdout0_29ck145 = 1.1 time = 730
.meas tran vdout0_29ck145 FIND v(dout0_29) AT=730.025n

* CHECK dout0_30 Vdout0_30ck145 = 0 time = 730
.meas tran vdout0_30ck145 FIND v(dout0_30) AT=730.025n

* CHECK dout0_31 Vdout0_31ck145 = 1.1 time = 730
.meas tran vdout0_31ck145 FIND v(dout0_31) AT=730.025n

* CHECK dout0_0 Vdout0_0ck146 = 0 time = 735
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=735.025n

* CHECK dout0_1 Vdout0_1ck146 = 1.1 time = 735
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=735.025n

* CHECK dout0_2 Vdout0_2ck146 = 0 time = 735
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=735.025n

* CHECK dout0_3 Vdout0_3ck146 = 0 time = 735
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=735.025n

* CHECK dout0_4 Vdout0_4ck146 = 0 time = 735
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=735.025n

* CHECK dout0_5 Vdout0_5ck146 = 1.1 time = 735
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=735.025n

* CHECK dout0_6 Vdout0_6ck146 = 1.1 time = 735
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=735.025n

* CHECK dout0_7 Vdout0_7ck146 = 1.1 time = 735
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=735.025n

* CHECK dout0_8 Vdout0_8ck146 = 1.1 time = 735
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=735.025n

* CHECK dout0_9 Vdout0_9ck146 = 1.1 time = 735
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=735.025n

* CHECK dout0_10 Vdout0_10ck146 = 1.1 time = 735
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=735.025n

* CHECK dout0_11 Vdout0_11ck146 = 0 time = 735
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=735.025n

* CHECK dout0_12 Vdout0_12ck146 = 1.1 time = 735
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=735.025n

* CHECK dout0_13 Vdout0_13ck146 = 1.1 time = 735
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=735.025n

* CHECK dout0_14 Vdout0_14ck146 = 1.1 time = 735
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=735.025n

* CHECK dout0_15 Vdout0_15ck146 = 1.1 time = 735
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=735.025n

* CHECK dout0_16 Vdout0_16ck146 = 1.1 time = 735
.meas tran vdout0_16ck146 FIND v(dout0_16) AT=735.025n

* CHECK dout0_17 Vdout0_17ck146 = 1.1 time = 735
.meas tran vdout0_17ck146 FIND v(dout0_17) AT=735.025n

* CHECK dout0_18 Vdout0_18ck146 = 0 time = 735
.meas tran vdout0_18ck146 FIND v(dout0_18) AT=735.025n

* CHECK dout0_19 Vdout0_19ck146 = 0 time = 735
.meas tran vdout0_19ck146 FIND v(dout0_19) AT=735.025n

* CHECK dout0_20 Vdout0_20ck146 = 0 time = 735
.meas tran vdout0_20ck146 FIND v(dout0_20) AT=735.025n

* CHECK dout0_21 Vdout0_21ck146 = 1.1 time = 735
.meas tran vdout0_21ck146 FIND v(dout0_21) AT=735.025n

* CHECK dout0_22 Vdout0_22ck146 = 1.1 time = 735
.meas tran vdout0_22ck146 FIND v(dout0_22) AT=735.025n

* CHECK dout0_23 Vdout0_23ck146 = 0 time = 735
.meas tran vdout0_23ck146 FIND v(dout0_23) AT=735.025n

* CHECK dout0_24 Vdout0_24ck146 = 1.1 time = 735
.meas tran vdout0_24ck146 FIND v(dout0_24) AT=735.025n

* CHECK dout0_25 Vdout0_25ck146 = 1.1 time = 735
.meas tran vdout0_25ck146 FIND v(dout0_25) AT=735.025n

* CHECK dout0_26 Vdout0_26ck146 = 1.1 time = 735
.meas tran vdout0_26ck146 FIND v(dout0_26) AT=735.025n

* CHECK dout0_27 Vdout0_27ck146 = 1.1 time = 735
.meas tran vdout0_27ck146 FIND v(dout0_27) AT=735.025n

* CHECK dout0_28 Vdout0_28ck146 = 1.1 time = 735
.meas tran vdout0_28ck146 FIND v(dout0_28) AT=735.025n

* CHECK dout0_29 Vdout0_29ck146 = 0 time = 735
.meas tran vdout0_29ck146 FIND v(dout0_29) AT=735.025n

* CHECK dout0_30 Vdout0_30ck146 = 1.1 time = 735
.meas tran vdout0_30ck146 FIND v(dout0_30) AT=735.025n

* CHECK dout0_31 Vdout0_31ck146 = 0 time = 735
.meas tran vdout0_31ck146 FIND v(dout0_31) AT=735.025n

* CHECK dout0_0 Vdout0_0ck148 = 1.1 time = 745
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=745.025n

* CHECK dout0_1 Vdout0_1ck148 = 0 time = 745
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=745.025n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 745
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=745.025n

* CHECK dout0_3 Vdout0_3ck148 = 1.1 time = 745
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=745.025n

* CHECK dout0_4 Vdout0_4ck148 = 0 time = 745
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=745.025n

* CHECK dout0_5 Vdout0_5ck148 = 1.1 time = 745
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=745.025n

* CHECK dout0_6 Vdout0_6ck148 = 1.1 time = 745
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=745.025n

* CHECK dout0_7 Vdout0_7ck148 = 0 time = 745
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=745.025n

* CHECK dout0_8 Vdout0_8ck148 = 1.1 time = 745
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=745.025n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 745
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=745.025n

* CHECK dout0_10 Vdout0_10ck148 = 0 time = 745
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=745.025n

* CHECK dout0_11 Vdout0_11ck148 = 1.1 time = 745
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=745.025n

* CHECK dout0_12 Vdout0_12ck148 = 0 time = 745
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=745.025n

* CHECK dout0_13 Vdout0_13ck148 = 1.1 time = 745
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=745.025n

* CHECK dout0_14 Vdout0_14ck148 = 1.1 time = 745
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=745.025n

* CHECK dout0_15 Vdout0_15ck148 = 0 time = 745
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=745.025n

* CHECK dout0_16 Vdout0_16ck148 = 1.1 time = 745
.meas tran vdout0_16ck148 FIND v(dout0_16) AT=745.025n

* CHECK dout0_17 Vdout0_17ck148 = 0 time = 745
.meas tran vdout0_17ck148 FIND v(dout0_17) AT=745.025n

* CHECK dout0_18 Vdout0_18ck148 = 0 time = 745
.meas tran vdout0_18ck148 FIND v(dout0_18) AT=745.025n

* CHECK dout0_19 Vdout0_19ck148 = 1.1 time = 745
.meas tran vdout0_19ck148 FIND v(dout0_19) AT=745.025n

* CHECK dout0_20 Vdout0_20ck148 = 1.1 time = 745
.meas tran vdout0_20ck148 FIND v(dout0_20) AT=745.025n

* CHECK dout0_21 Vdout0_21ck148 = 0 time = 745
.meas tran vdout0_21ck148 FIND v(dout0_21) AT=745.025n

* CHECK dout0_22 Vdout0_22ck148 = 1.1 time = 745
.meas tran vdout0_22ck148 FIND v(dout0_22) AT=745.025n

* CHECK dout0_23 Vdout0_23ck148 = 0 time = 745
.meas tran vdout0_23ck148 FIND v(dout0_23) AT=745.025n

* CHECK dout0_24 Vdout0_24ck148 = 0 time = 745
.meas tran vdout0_24ck148 FIND v(dout0_24) AT=745.025n

* CHECK dout0_25 Vdout0_25ck148 = 0 time = 745
.meas tran vdout0_25ck148 FIND v(dout0_25) AT=745.025n

* CHECK dout0_26 Vdout0_26ck148 = 1.1 time = 745
.meas tran vdout0_26ck148 FIND v(dout0_26) AT=745.025n

* CHECK dout0_27 Vdout0_27ck148 = 0 time = 745
.meas tran vdout0_27ck148 FIND v(dout0_27) AT=745.025n

* CHECK dout0_28 Vdout0_28ck148 = 0 time = 745
.meas tran vdout0_28ck148 FIND v(dout0_28) AT=745.025n

* CHECK dout0_29 Vdout0_29ck148 = 1.1 time = 745
.meas tran vdout0_29ck148 FIND v(dout0_29) AT=745.025n

* CHECK dout0_30 Vdout0_30ck148 = 1.1 time = 745
.meas tran vdout0_30ck148 FIND v(dout0_30) AT=745.025n

* CHECK dout0_31 Vdout0_31ck148 = 1.1 time = 745
.meas tran vdout0_31ck148 FIND v(dout0_31) AT=745.025n

* CHECK dout0_0 Vdout0_0ck149 = 0 time = 750
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=750.025n

* CHECK dout0_1 Vdout0_1ck149 = 0 time = 750
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=750.025n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 750
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=750.025n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 750
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=750.025n

* CHECK dout0_4 Vdout0_4ck149 = 0 time = 750
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=750.025n

* CHECK dout0_5 Vdout0_5ck149 = 0 time = 750
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=750.025n

* CHECK dout0_6 Vdout0_6ck149 = 0 time = 750
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=750.025n

* CHECK dout0_7 Vdout0_7ck149 = 0 time = 750
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=750.025n

* CHECK dout0_8 Vdout0_8ck149 = 0 time = 750
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=750.025n

* CHECK dout0_9 Vdout0_9ck149 = 1.1 time = 750
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=750.025n

* CHECK dout0_10 Vdout0_10ck149 = 1.1 time = 750
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=750.025n

* CHECK dout0_11 Vdout0_11ck149 = 1.1 time = 750
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=750.025n

* CHECK dout0_12 Vdout0_12ck149 = 0 time = 750
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=750.025n

* CHECK dout0_13 Vdout0_13ck149 = 0 time = 750
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=750.025n

* CHECK dout0_14 Vdout0_14ck149 = 0 time = 750
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=750.025n

* CHECK dout0_15 Vdout0_15ck149 = 1.1 time = 750
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=750.025n

* CHECK dout0_16 Vdout0_16ck149 = 1.1 time = 750
.meas tran vdout0_16ck149 FIND v(dout0_16) AT=750.025n

* CHECK dout0_17 Vdout0_17ck149 = 0 time = 750
.meas tran vdout0_17ck149 FIND v(dout0_17) AT=750.025n

* CHECK dout0_18 Vdout0_18ck149 = 0 time = 750
.meas tran vdout0_18ck149 FIND v(dout0_18) AT=750.025n

* CHECK dout0_19 Vdout0_19ck149 = 1.1 time = 750
.meas tran vdout0_19ck149 FIND v(dout0_19) AT=750.025n

* CHECK dout0_20 Vdout0_20ck149 = 0 time = 750
.meas tran vdout0_20ck149 FIND v(dout0_20) AT=750.025n

* CHECK dout0_21 Vdout0_21ck149 = 0 time = 750
.meas tran vdout0_21ck149 FIND v(dout0_21) AT=750.025n

* CHECK dout0_22 Vdout0_22ck149 = 0 time = 750
.meas tran vdout0_22ck149 FIND v(dout0_22) AT=750.025n

* CHECK dout0_23 Vdout0_23ck149 = 0 time = 750
.meas tran vdout0_23ck149 FIND v(dout0_23) AT=750.025n

* CHECK dout0_24 Vdout0_24ck149 = 0 time = 750
.meas tran vdout0_24ck149 FIND v(dout0_24) AT=750.025n

* CHECK dout0_25 Vdout0_25ck149 = 0 time = 750
.meas tran vdout0_25ck149 FIND v(dout0_25) AT=750.025n

* CHECK dout0_26 Vdout0_26ck149 = 0 time = 750
.meas tran vdout0_26ck149 FIND v(dout0_26) AT=750.025n

* CHECK dout0_27 Vdout0_27ck149 = 1.1 time = 750
.meas tran vdout0_27ck149 FIND v(dout0_27) AT=750.025n

* CHECK dout0_28 Vdout0_28ck149 = 0 time = 750
.meas tran vdout0_28ck149 FIND v(dout0_28) AT=750.025n

* CHECK dout0_29 Vdout0_29ck149 = 0 time = 750
.meas tran vdout0_29ck149 FIND v(dout0_29) AT=750.025n

* CHECK dout0_30 Vdout0_30ck149 = 1.1 time = 750
.meas tran vdout0_30ck149 FIND v(dout0_30) AT=750.025n

* CHECK dout0_31 Vdout0_31ck149 = 1.1 time = 750
.meas tran vdout0_31ck149 FIND v(dout0_31) AT=750.025n

* CHECK dout0_0 Vdout0_0ck150 = 0 time = 755
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=755.025n

* CHECK dout0_1 Vdout0_1ck150 = 1.1 time = 755
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=755.025n

* CHECK dout0_2 Vdout0_2ck150 = 0 time = 755
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=755.025n

* CHECK dout0_3 Vdout0_3ck150 = 1.1 time = 755
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=755.025n

* CHECK dout0_4 Vdout0_4ck150 = 1.1 time = 755
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=755.025n

* CHECK dout0_5 Vdout0_5ck150 = 1.1 time = 755
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=755.025n

* CHECK dout0_6 Vdout0_6ck150 = 1.1 time = 755
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=755.025n

* CHECK dout0_7 Vdout0_7ck150 = 0 time = 755
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=755.025n

* CHECK dout0_8 Vdout0_8ck150 = 1.1 time = 755
.meas tran vdout0_8ck150 FIND v(dout0_8) AT=755.025n

* CHECK dout0_9 Vdout0_9ck150 = 1.1 time = 755
.meas tran vdout0_9ck150 FIND v(dout0_9) AT=755.025n

* CHECK dout0_10 Vdout0_10ck150 = 0 time = 755
.meas tran vdout0_10ck150 FIND v(dout0_10) AT=755.025n

* CHECK dout0_11 Vdout0_11ck150 = 1.1 time = 755
.meas tran vdout0_11ck150 FIND v(dout0_11) AT=755.025n

* CHECK dout0_12 Vdout0_12ck150 = 0 time = 755
.meas tran vdout0_12ck150 FIND v(dout0_12) AT=755.025n

* CHECK dout0_13 Vdout0_13ck150 = 1.1 time = 755
.meas tran vdout0_13ck150 FIND v(dout0_13) AT=755.025n

* CHECK dout0_14 Vdout0_14ck150 = 0 time = 755
.meas tran vdout0_14ck150 FIND v(dout0_14) AT=755.025n

* CHECK dout0_15 Vdout0_15ck150 = 0 time = 755
.meas tran vdout0_15ck150 FIND v(dout0_15) AT=755.025n

* CHECK dout0_16 Vdout0_16ck150 = 1.1 time = 755
.meas tran vdout0_16ck150 FIND v(dout0_16) AT=755.025n

* CHECK dout0_17 Vdout0_17ck150 = 0 time = 755
.meas tran vdout0_17ck150 FIND v(dout0_17) AT=755.025n

* CHECK dout0_18 Vdout0_18ck150 = 0 time = 755
.meas tran vdout0_18ck150 FIND v(dout0_18) AT=755.025n

* CHECK dout0_19 Vdout0_19ck150 = 1.1 time = 755
.meas tran vdout0_19ck150 FIND v(dout0_19) AT=755.025n

* CHECK dout0_20 Vdout0_20ck150 = 0 time = 755
.meas tran vdout0_20ck150 FIND v(dout0_20) AT=755.025n

* CHECK dout0_21 Vdout0_21ck150 = 0 time = 755
.meas tran vdout0_21ck150 FIND v(dout0_21) AT=755.025n

* CHECK dout0_22 Vdout0_22ck150 = 0 time = 755
.meas tran vdout0_22ck150 FIND v(dout0_22) AT=755.025n

* CHECK dout0_23 Vdout0_23ck150 = 0 time = 755
.meas tran vdout0_23ck150 FIND v(dout0_23) AT=755.025n

* CHECK dout0_24 Vdout0_24ck150 = 0 time = 755
.meas tran vdout0_24ck150 FIND v(dout0_24) AT=755.025n

* CHECK dout0_25 Vdout0_25ck150 = 1.1 time = 755
.meas tran vdout0_25ck150 FIND v(dout0_25) AT=755.025n

* CHECK dout0_26 Vdout0_26ck150 = 1.1 time = 755
.meas tran vdout0_26ck150 FIND v(dout0_26) AT=755.025n

* CHECK dout0_27 Vdout0_27ck150 = 1.1 time = 755
.meas tran vdout0_27ck150 FIND v(dout0_27) AT=755.025n

* CHECK dout0_28 Vdout0_28ck150 = 0 time = 755
.meas tran vdout0_28ck150 FIND v(dout0_28) AT=755.025n

* CHECK dout0_29 Vdout0_29ck150 = 0 time = 755
.meas tran vdout0_29ck150 FIND v(dout0_29) AT=755.025n

* CHECK dout0_30 Vdout0_30ck150 = 1.1 time = 755
.meas tran vdout0_30ck150 FIND v(dout0_30) AT=755.025n

* CHECK dout0_31 Vdout0_31ck150 = 0 time = 755
.meas tran vdout0_31ck150 FIND v(dout0_31) AT=755.025n

* CHECK dout0_0 Vdout0_0ck151 = 1.1 time = 760
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=760.025n

* CHECK dout0_1 Vdout0_1ck151 = 0 time = 760
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=760.025n

* CHECK dout0_2 Vdout0_2ck151 = 0 time = 760
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=760.025n

* CHECK dout0_3 Vdout0_3ck151 = 1.1 time = 760
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=760.025n

* CHECK dout0_4 Vdout0_4ck151 = 1.1 time = 760
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=760.025n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 760
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=760.025n

* CHECK dout0_6 Vdout0_6ck151 = 1.1 time = 760
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=760.025n

* CHECK dout0_7 Vdout0_7ck151 = 0 time = 760
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=760.025n

* CHECK dout0_8 Vdout0_8ck151 = 0 time = 760
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=760.025n

* CHECK dout0_9 Vdout0_9ck151 = 1.1 time = 760
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=760.025n

* CHECK dout0_10 Vdout0_10ck151 = 1.1 time = 760
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=760.025n

* CHECK dout0_11 Vdout0_11ck151 = 1.1 time = 760
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=760.025n

* CHECK dout0_12 Vdout0_12ck151 = 1.1 time = 760
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=760.025n

* CHECK dout0_13 Vdout0_13ck151 = 1.1 time = 760
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=760.025n

* CHECK dout0_14 Vdout0_14ck151 = 1.1 time = 760
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=760.025n

* CHECK dout0_15 Vdout0_15ck151 = 1.1 time = 760
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=760.025n

* CHECK dout0_16 Vdout0_16ck151 = 0 time = 760
.meas tran vdout0_16ck151 FIND v(dout0_16) AT=760.025n

* CHECK dout0_17 Vdout0_17ck151 = 0 time = 760
.meas tran vdout0_17ck151 FIND v(dout0_17) AT=760.025n

* CHECK dout0_18 Vdout0_18ck151 = 0 time = 760
.meas tran vdout0_18ck151 FIND v(dout0_18) AT=760.025n

* CHECK dout0_19 Vdout0_19ck151 = 0 time = 760
.meas tran vdout0_19ck151 FIND v(dout0_19) AT=760.025n

* CHECK dout0_20 Vdout0_20ck151 = 0 time = 760
.meas tran vdout0_20ck151 FIND v(dout0_20) AT=760.025n

* CHECK dout0_21 Vdout0_21ck151 = 1.1 time = 760
.meas tran vdout0_21ck151 FIND v(dout0_21) AT=760.025n

* CHECK dout0_22 Vdout0_22ck151 = 1.1 time = 760
.meas tran vdout0_22ck151 FIND v(dout0_22) AT=760.025n

* CHECK dout0_23 Vdout0_23ck151 = 0 time = 760
.meas tran vdout0_23ck151 FIND v(dout0_23) AT=760.025n

* CHECK dout0_24 Vdout0_24ck151 = 1.1 time = 760
.meas tran vdout0_24ck151 FIND v(dout0_24) AT=760.025n

* CHECK dout0_25 Vdout0_25ck151 = 1.1 time = 760
.meas tran vdout0_25ck151 FIND v(dout0_25) AT=760.025n

* CHECK dout0_26 Vdout0_26ck151 = 1.1 time = 760
.meas tran vdout0_26ck151 FIND v(dout0_26) AT=760.025n

* CHECK dout0_27 Vdout0_27ck151 = 1.1 time = 760
.meas tran vdout0_27ck151 FIND v(dout0_27) AT=760.025n

* CHECK dout0_28 Vdout0_28ck151 = 1.1 time = 760
.meas tran vdout0_28ck151 FIND v(dout0_28) AT=760.025n

* CHECK dout0_29 Vdout0_29ck151 = 1.1 time = 760
.meas tran vdout0_29ck151 FIND v(dout0_29) AT=760.025n

* CHECK dout0_30 Vdout0_30ck151 = 0 time = 760
.meas tran vdout0_30ck151 FIND v(dout0_30) AT=760.025n

* CHECK dout0_31 Vdout0_31ck151 = 1.1 time = 760
.meas tran vdout0_31ck151 FIND v(dout0_31) AT=760.025n

* CHECK dout0_0 Vdout0_0ck152 = 0 time = 765
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=765.025n

* CHECK dout0_1 Vdout0_1ck152 = 1.1 time = 765
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=765.025n

* CHECK dout0_2 Vdout0_2ck152 = 1.1 time = 765
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=765.025n

* CHECK dout0_3 Vdout0_3ck152 = 1.1 time = 765
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=765.025n

* CHECK dout0_4 Vdout0_4ck152 = 0 time = 765
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=765.025n

* CHECK dout0_5 Vdout0_5ck152 = 1.1 time = 765
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=765.025n

* CHECK dout0_6 Vdout0_6ck152 = 0 time = 765
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=765.025n

* CHECK dout0_7 Vdout0_7ck152 = 1.1 time = 765
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=765.025n

* CHECK dout0_8 Vdout0_8ck152 = 0 time = 765
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=765.025n

* CHECK dout0_9 Vdout0_9ck152 = 0 time = 765
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=765.025n

* CHECK dout0_10 Vdout0_10ck152 = 0 time = 765
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=765.025n

* CHECK dout0_11 Vdout0_11ck152 = 1.1 time = 765
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=765.025n

* CHECK dout0_12 Vdout0_12ck152 = 0 time = 765
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=765.025n

* CHECK dout0_13 Vdout0_13ck152 = 1.1 time = 765
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=765.025n

* CHECK dout0_14 Vdout0_14ck152 = 1.1 time = 765
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=765.025n

* CHECK dout0_15 Vdout0_15ck152 = 1.1 time = 765
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=765.025n

* CHECK dout0_16 Vdout0_16ck152 = 1.1 time = 765
.meas tran vdout0_16ck152 FIND v(dout0_16) AT=765.025n

* CHECK dout0_17 Vdout0_17ck152 = 0 time = 765
.meas tran vdout0_17ck152 FIND v(dout0_17) AT=765.025n

* CHECK dout0_18 Vdout0_18ck152 = 0 time = 765
.meas tran vdout0_18ck152 FIND v(dout0_18) AT=765.025n

* CHECK dout0_19 Vdout0_19ck152 = 1.1 time = 765
.meas tran vdout0_19ck152 FIND v(dout0_19) AT=765.025n

* CHECK dout0_20 Vdout0_20ck152 = 1.1 time = 765
.meas tran vdout0_20ck152 FIND v(dout0_20) AT=765.025n

* CHECK dout0_21 Vdout0_21ck152 = 1.1 time = 765
.meas tran vdout0_21ck152 FIND v(dout0_21) AT=765.025n

* CHECK dout0_22 Vdout0_22ck152 = 0 time = 765
.meas tran vdout0_22ck152 FIND v(dout0_22) AT=765.025n

* CHECK dout0_23 Vdout0_23ck152 = 0 time = 765
.meas tran vdout0_23ck152 FIND v(dout0_23) AT=765.025n

* CHECK dout0_24 Vdout0_24ck152 = 1.1 time = 765
.meas tran vdout0_24ck152 FIND v(dout0_24) AT=765.025n

* CHECK dout0_25 Vdout0_25ck152 = 0 time = 765
.meas tran vdout0_25ck152 FIND v(dout0_25) AT=765.025n

* CHECK dout0_26 Vdout0_26ck152 = 1.1 time = 765
.meas tran vdout0_26ck152 FIND v(dout0_26) AT=765.025n

* CHECK dout0_27 Vdout0_27ck152 = 1.1 time = 765
.meas tran vdout0_27ck152 FIND v(dout0_27) AT=765.025n

* CHECK dout0_28 Vdout0_28ck152 = 0 time = 765
.meas tran vdout0_28ck152 FIND v(dout0_28) AT=765.025n

* CHECK dout0_29 Vdout0_29ck152 = 0 time = 765
.meas tran vdout0_29ck152 FIND v(dout0_29) AT=765.025n

* CHECK dout0_30 Vdout0_30ck152 = 1.1 time = 765
.meas tran vdout0_30ck152 FIND v(dout0_30) AT=765.025n

* CHECK dout0_31 Vdout0_31ck152 = 1.1 time = 765
.meas tran vdout0_31ck152 FIND v(dout0_31) AT=765.025n

* CHECK dout0_0 Vdout0_0ck153 = 0 time = 770
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=770.025n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 770
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=770.025n

* CHECK dout0_2 Vdout0_2ck153 = 0 time = 770
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=770.025n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 770
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=770.025n

* CHECK dout0_4 Vdout0_4ck153 = 0 time = 770
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=770.025n

* CHECK dout0_5 Vdout0_5ck153 = 0 time = 770
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=770.025n

* CHECK dout0_6 Vdout0_6ck153 = 0 time = 770
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=770.025n

* CHECK dout0_7 Vdout0_7ck153 = 0 time = 770
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=770.025n

* CHECK dout0_8 Vdout0_8ck153 = 0 time = 770
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=770.025n

* CHECK dout0_9 Vdout0_9ck153 = 1.1 time = 770
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=770.025n

* CHECK dout0_10 Vdout0_10ck153 = 1.1 time = 770
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=770.025n

* CHECK dout0_11 Vdout0_11ck153 = 1.1 time = 770
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=770.025n

* CHECK dout0_12 Vdout0_12ck153 = 0 time = 770
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=770.025n

* CHECK dout0_13 Vdout0_13ck153 = 0 time = 770
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=770.025n

* CHECK dout0_14 Vdout0_14ck153 = 0 time = 770
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=770.025n

* CHECK dout0_15 Vdout0_15ck153 = 1.1 time = 770
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=770.025n

* CHECK dout0_16 Vdout0_16ck153 = 1.1 time = 770
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=770.025n

* CHECK dout0_17 Vdout0_17ck153 = 0 time = 770
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=770.025n

* CHECK dout0_18 Vdout0_18ck153 = 0 time = 770
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=770.025n

* CHECK dout0_19 Vdout0_19ck153 = 1.1 time = 770
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=770.025n

* CHECK dout0_20 Vdout0_20ck153 = 0 time = 770
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=770.025n

* CHECK dout0_21 Vdout0_21ck153 = 0 time = 770
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=770.025n

* CHECK dout0_22 Vdout0_22ck153 = 0 time = 770
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=770.025n

* CHECK dout0_23 Vdout0_23ck153 = 0 time = 770
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=770.025n

* CHECK dout0_24 Vdout0_24ck153 = 0 time = 770
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=770.025n

* CHECK dout0_25 Vdout0_25ck153 = 0 time = 770
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=770.025n

* CHECK dout0_26 Vdout0_26ck153 = 0 time = 770
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=770.025n

* CHECK dout0_27 Vdout0_27ck153 = 1.1 time = 770
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=770.025n

* CHECK dout0_28 Vdout0_28ck153 = 0 time = 770
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=770.025n

* CHECK dout0_29 Vdout0_29ck153 = 0 time = 770
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=770.025n

* CHECK dout0_30 Vdout0_30ck153 = 1.1 time = 770
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=770.025n

* CHECK dout0_31 Vdout0_31ck153 = 1.1 time = 770
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=770.025n

* CHECK dout0_0 Vdout0_0ck154 = 0 time = 775
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=775.025n

* CHECK dout0_1 Vdout0_1ck154 = 1.1 time = 775
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=775.025n

* CHECK dout0_2 Vdout0_2ck154 = 0 time = 775
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=775.025n

* CHECK dout0_3 Vdout0_3ck154 = 1.1 time = 775
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=775.025n

* CHECK dout0_4 Vdout0_4ck154 = 1.1 time = 775
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=775.025n

* CHECK dout0_5 Vdout0_5ck154 = 1.1 time = 775
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=775.025n

* CHECK dout0_6 Vdout0_6ck154 = 0 time = 775
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=775.025n

* CHECK dout0_7 Vdout0_7ck154 = 0 time = 775
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=775.025n

* CHECK dout0_8 Vdout0_8ck154 = 0 time = 775
.meas tran vdout0_8ck154 FIND v(dout0_8) AT=775.025n

* CHECK dout0_9 Vdout0_9ck154 = 0 time = 775
.meas tran vdout0_9ck154 FIND v(dout0_9) AT=775.025n

* CHECK dout0_10 Vdout0_10ck154 = 1.1 time = 775
.meas tran vdout0_10ck154 FIND v(dout0_10) AT=775.025n

* CHECK dout0_11 Vdout0_11ck154 = 1.1 time = 775
.meas tran vdout0_11ck154 FIND v(dout0_11) AT=775.025n

* CHECK dout0_12 Vdout0_12ck154 = 1.1 time = 775
.meas tran vdout0_12ck154 FIND v(dout0_12) AT=775.025n

* CHECK dout0_13 Vdout0_13ck154 = 1.1 time = 775
.meas tran vdout0_13ck154 FIND v(dout0_13) AT=775.025n

* CHECK dout0_14 Vdout0_14ck154 = 0 time = 775
.meas tran vdout0_14ck154 FIND v(dout0_14) AT=775.025n

* CHECK dout0_15 Vdout0_15ck154 = 0 time = 775
.meas tran vdout0_15ck154 FIND v(dout0_15) AT=775.025n

* CHECK dout0_16 Vdout0_16ck154 = 1.1 time = 775
.meas tran vdout0_16ck154 FIND v(dout0_16) AT=775.025n

* CHECK dout0_17 Vdout0_17ck154 = 0 time = 775
.meas tran vdout0_17ck154 FIND v(dout0_17) AT=775.025n

* CHECK dout0_18 Vdout0_18ck154 = 1.1 time = 775
.meas tran vdout0_18ck154 FIND v(dout0_18) AT=775.025n

* CHECK dout0_19 Vdout0_19ck154 = 1.1 time = 775
.meas tran vdout0_19ck154 FIND v(dout0_19) AT=775.025n

* CHECK dout0_20 Vdout0_20ck154 = 1.1 time = 775
.meas tran vdout0_20ck154 FIND v(dout0_20) AT=775.025n

* CHECK dout0_21 Vdout0_21ck154 = 1.1 time = 775
.meas tran vdout0_21ck154 FIND v(dout0_21) AT=775.025n

* CHECK dout0_22 Vdout0_22ck154 = 1.1 time = 775
.meas tran vdout0_22ck154 FIND v(dout0_22) AT=775.025n

* CHECK dout0_23 Vdout0_23ck154 = 0 time = 775
.meas tran vdout0_23ck154 FIND v(dout0_23) AT=775.025n

* CHECK dout0_24 Vdout0_24ck154 = 0 time = 775
.meas tran vdout0_24ck154 FIND v(dout0_24) AT=775.025n

* CHECK dout0_25 Vdout0_25ck154 = 0 time = 775
.meas tran vdout0_25ck154 FIND v(dout0_25) AT=775.025n

* CHECK dout0_26 Vdout0_26ck154 = 0 time = 775
.meas tran vdout0_26ck154 FIND v(dout0_26) AT=775.025n

* CHECK dout0_27 Vdout0_27ck154 = 0 time = 775
.meas tran vdout0_27ck154 FIND v(dout0_27) AT=775.025n

* CHECK dout0_28 Vdout0_28ck154 = 0 time = 775
.meas tran vdout0_28ck154 FIND v(dout0_28) AT=775.025n

* CHECK dout0_29 Vdout0_29ck154 = 1.1 time = 775
.meas tran vdout0_29ck154 FIND v(dout0_29) AT=775.025n

* CHECK dout0_30 Vdout0_30ck154 = 0 time = 775
.meas tran vdout0_30ck154 FIND v(dout0_30) AT=775.025n

* CHECK dout0_31 Vdout0_31ck154 = 1.1 time = 775
.meas tran vdout0_31ck154 FIND v(dout0_31) AT=775.025n

* CHECK dout0_0 Vdout0_0ck155 = 0 time = 780
.meas tran vdout0_0ck155 FIND v(dout0_0) AT=780.025n

* CHECK dout0_1 Vdout0_1ck155 = 1.1 time = 780
.meas tran vdout0_1ck155 FIND v(dout0_1) AT=780.025n

* CHECK dout0_2 Vdout0_2ck155 = 1.1 time = 780
.meas tran vdout0_2ck155 FIND v(dout0_2) AT=780.025n

* CHECK dout0_3 Vdout0_3ck155 = 1.1 time = 780
.meas tran vdout0_3ck155 FIND v(dout0_3) AT=780.025n

* CHECK dout0_4 Vdout0_4ck155 = 0 time = 780
.meas tran vdout0_4ck155 FIND v(dout0_4) AT=780.025n

* CHECK dout0_5 Vdout0_5ck155 = 1.1 time = 780
.meas tran vdout0_5ck155 FIND v(dout0_5) AT=780.025n

* CHECK dout0_6 Vdout0_6ck155 = 0 time = 780
.meas tran vdout0_6ck155 FIND v(dout0_6) AT=780.025n

* CHECK dout0_7 Vdout0_7ck155 = 1.1 time = 780
.meas tran vdout0_7ck155 FIND v(dout0_7) AT=780.025n

* CHECK dout0_8 Vdout0_8ck155 = 0 time = 780
.meas tran vdout0_8ck155 FIND v(dout0_8) AT=780.025n

* CHECK dout0_9 Vdout0_9ck155 = 0 time = 780
.meas tran vdout0_9ck155 FIND v(dout0_9) AT=780.025n

* CHECK dout0_10 Vdout0_10ck155 = 0 time = 780
.meas tran vdout0_10ck155 FIND v(dout0_10) AT=780.025n

* CHECK dout0_11 Vdout0_11ck155 = 1.1 time = 780
.meas tran vdout0_11ck155 FIND v(dout0_11) AT=780.025n

* CHECK dout0_12 Vdout0_12ck155 = 0 time = 780
.meas tran vdout0_12ck155 FIND v(dout0_12) AT=780.025n

* CHECK dout0_13 Vdout0_13ck155 = 1.1 time = 780
.meas tran vdout0_13ck155 FIND v(dout0_13) AT=780.025n

* CHECK dout0_14 Vdout0_14ck155 = 1.1 time = 780
.meas tran vdout0_14ck155 FIND v(dout0_14) AT=780.025n

* CHECK dout0_15 Vdout0_15ck155 = 1.1 time = 780
.meas tran vdout0_15ck155 FIND v(dout0_15) AT=780.025n

* CHECK dout0_16 Vdout0_16ck155 = 1.1 time = 780
.meas tran vdout0_16ck155 FIND v(dout0_16) AT=780.025n

* CHECK dout0_17 Vdout0_17ck155 = 0 time = 780
.meas tran vdout0_17ck155 FIND v(dout0_17) AT=780.025n

* CHECK dout0_18 Vdout0_18ck155 = 0 time = 780
.meas tran vdout0_18ck155 FIND v(dout0_18) AT=780.025n

* CHECK dout0_19 Vdout0_19ck155 = 1.1 time = 780
.meas tran vdout0_19ck155 FIND v(dout0_19) AT=780.025n

* CHECK dout0_20 Vdout0_20ck155 = 1.1 time = 780
.meas tran vdout0_20ck155 FIND v(dout0_20) AT=780.025n

* CHECK dout0_21 Vdout0_21ck155 = 1.1 time = 780
.meas tran vdout0_21ck155 FIND v(dout0_21) AT=780.025n

* CHECK dout0_22 Vdout0_22ck155 = 0 time = 780
.meas tran vdout0_22ck155 FIND v(dout0_22) AT=780.025n

* CHECK dout0_23 Vdout0_23ck155 = 0 time = 780
.meas tran vdout0_23ck155 FIND v(dout0_23) AT=780.025n

* CHECK dout0_24 Vdout0_24ck155 = 1.1 time = 780
.meas tran vdout0_24ck155 FIND v(dout0_24) AT=780.025n

* CHECK dout0_25 Vdout0_25ck155 = 0 time = 780
.meas tran vdout0_25ck155 FIND v(dout0_25) AT=780.025n

* CHECK dout0_26 Vdout0_26ck155 = 1.1 time = 780
.meas tran vdout0_26ck155 FIND v(dout0_26) AT=780.025n

* CHECK dout0_27 Vdout0_27ck155 = 1.1 time = 780
.meas tran vdout0_27ck155 FIND v(dout0_27) AT=780.025n

* CHECK dout0_28 Vdout0_28ck155 = 0 time = 780
.meas tran vdout0_28ck155 FIND v(dout0_28) AT=780.025n

* CHECK dout0_29 Vdout0_29ck155 = 0 time = 780
.meas tran vdout0_29ck155 FIND v(dout0_29) AT=780.025n

* CHECK dout0_30 Vdout0_30ck155 = 1.1 time = 780
.meas tran vdout0_30ck155 FIND v(dout0_30) AT=780.025n

* CHECK dout0_31 Vdout0_31ck155 = 1.1 time = 780
.meas tran vdout0_31ck155 FIND v(dout0_31) AT=780.025n

* CHECK dout0_0 Vdout0_0ck156 = 1.1 time = 785
.meas tran vdout0_0ck156 FIND v(dout0_0) AT=785.025n

* CHECK dout0_1 Vdout0_1ck156 = 0 time = 785
.meas tran vdout0_1ck156 FIND v(dout0_1) AT=785.025n

* CHECK dout0_2 Vdout0_2ck156 = 0 time = 785
.meas tran vdout0_2ck156 FIND v(dout0_2) AT=785.025n

* CHECK dout0_3 Vdout0_3ck156 = 1.1 time = 785
.meas tran vdout0_3ck156 FIND v(dout0_3) AT=785.025n

* CHECK dout0_4 Vdout0_4ck156 = 0 time = 785
.meas tran vdout0_4ck156 FIND v(dout0_4) AT=785.025n

* CHECK dout0_5 Vdout0_5ck156 = 1.1 time = 785
.meas tran vdout0_5ck156 FIND v(dout0_5) AT=785.025n

* CHECK dout0_6 Vdout0_6ck156 = 1.1 time = 785
.meas tran vdout0_6ck156 FIND v(dout0_6) AT=785.025n

* CHECK dout0_7 Vdout0_7ck156 = 0 time = 785
.meas tran vdout0_7ck156 FIND v(dout0_7) AT=785.025n

* CHECK dout0_8 Vdout0_8ck156 = 1.1 time = 785
.meas tran vdout0_8ck156 FIND v(dout0_8) AT=785.025n

* CHECK dout0_9 Vdout0_9ck156 = 0 time = 785
.meas tran vdout0_9ck156 FIND v(dout0_9) AT=785.025n

* CHECK dout0_10 Vdout0_10ck156 = 0 time = 785
.meas tran vdout0_10ck156 FIND v(dout0_10) AT=785.025n

* CHECK dout0_11 Vdout0_11ck156 = 1.1 time = 785
.meas tran vdout0_11ck156 FIND v(dout0_11) AT=785.025n

* CHECK dout0_12 Vdout0_12ck156 = 0 time = 785
.meas tran vdout0_12ck156 FIND v(dout0_12) AT=785.025n

* CHECK dout0_13 Vdout0_13ck156 = 1.1 time = 785
.meas tran vdout0_13ck156 FIND v(dout0_13) AT=785.025n

* CHECK dout0_14 Vdout0_14ck156 = 1.1 time = 785
.meas tran vdout0_14ck156 FIND v(dout0_14) AT=785.025n

* CHECK dout0_15 Vdout0_15ck156 = 0 time = 785
.meas tran vdout0_15ck156 FIND v(dout0_15) AT=785.025n

* CHECK dout0_16 Vdout0_16ck156 = 1.1 time = 785
.meas tran vdout0_16ck156 FIND v(dout0_16) AT=785.025n

* CHECK dout0_17 Vdout0_17ck156 = 0 time = 785
.meas tran vdout0_17ck156 FIND v(dout0_17) AT=785.025n

* CHECK dout0_18 Vdout0_18ck156 = 0 time = 785
.meas tran vdout0_18ck156 FIND v(dout0_18) AT=785.025n

* CHECK dout0_19 Vdout0_19ck156 = 1.1 time = 785
.meas tran vdout0_19ck156 FIND v(dout0_19) AT=785.025n

* CHECK dout0_20 Vdout0_20ck156 = 1.1 time = 785
.meas tran vdout0_20ck156 FIND v(dout0_20) AT=785.025n

* CHECK dout0_21 Vdout0_21ck156 = 0 time = 785
.meas tran vdout0_21ck156 FIND v(dout0_21) AT=785.025n

* CHECK dout0_22 Vdout0_22ck156 = 1.1 time = 785
.meas tran vdout0_22ck156 FIND v(dout0_22) AT=785.025n

* CHECK dout0_23 Vdout0_23ck156 = 0 time = 785
.meas tran vdout0_23ck156 FIND v(dout0_23) AT=785.025n

* CHECK dout0_24 Vdout0_24ck156 = 0 time = 785
.meas tran vdout0_24ck156 FIND v(dout0_24) AT=785.025n

* CHECK dout0_25 Vdout0_25ck156 = 0 time = 785
.meas tran vdout0_25ck156 FIND v(dout0_25) AT=785.025n

* CHECK dout0_26 Vdout0_26ck156 = 1.1 time = 785
.meas tran vdout0_26ck156 FIND v(dout0_26) AT=785.025n

* CHECK dout0_27 Vdout0_27ck156 = 0 time = 785
.meas tran vdout0_27ck156 FIND v(dout0_27) AT=785.025n

* CHECK dout0_28 Vdout0_28ck156 = 0 time = 785
.meas tran vdout0_28ck156 FIND v(dout0_28) AT=785.025n

* CHECK dout0_29 Vdout0_29ck156 = 1.1 time = 785
.meas tran vdout0_29ck156 FIND v(dout0_29) AT=785.025n

* CHECK dout0_30 Vdout0_30ck156 = 1.1 time = 785
.meas tran vdout0_30ck156 FIND v(dout0_30) AT=785.025n

* CHECK dout0_31 Vdout0_31ck156 = 1.1 time = 785
.meas tran vdout0_31ck156 FIND v(dout0_31) AT=785.025n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 795
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=795.025n

* CHECK dout0_1 Vdout0_1ck158 = 1.1 time = 795
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=795.025n

* CHECK dout0_2 Vdout0_2ck158 = 0 time = 795
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=795.025n

* CHECK dout0_3 Vdout0_3ck158 = 0 time = 795
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=795.025n

* CHECK dout0_4 Vdout0_4ck158 = 0 time = 795
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=795.025n

* CHECK dout0_5 Vdout0_5ck158 = 1.1 time = 795
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=795.025n

* CHECK dout0_6 Vdout0_6ck158 = 1.1 time = 795
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=795.025n

* CHECK dout0_7 Vdout0_7ck158 = 1.1 time = 795
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=795.025n

* CHECK dout0_8 Vdout0_8ck158 = 1.1 time = 795
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=795.025n

* CHECK dout0_9 Vdout0_9ck158 = 1.1 time = 795
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=795.025n

* CHECK dout0_10 Vdout0_10ck158 = 1.1 time = 795
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=795.025n

* CHECK dout0_11 Vdout0_11ck158 = 0 time = 795
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=795.025n

* CHECK dout0_12 Vdout0_12ck158 = 1.1 time = 795
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=795.025n

* CHECK dout0_13 Vdout0_13ck158 = 1.1 time = 795
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=795.025n

* CHECK dout0_14 Vdout0_14ck158 = 1.1 time = 795
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=795.025n

* CHECK dout0_15 Vdout0_15ck158 = 1.1 time = 795
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=795.025n

* CHECK dout0_16 Vdout0_16ck158 = 1.1 time = 795
.meas tran vdout0_16ck158 FIND v(dout0_16) AT=795.025n

* CHECK dout0_17 Vdout0_17ck158 = 1.1 time = 795
.meas tran vdout0_17ck158 FIND v(dout0_17) AT=795.025n

* CHECK dout0_18 Vdout0_18ck158 = 0 time = 795
.meas tran vdout0_18ck158 FIND v(dout0_18) AT=795.025n

* CHECK dout0_19 Vdout0_19ck158 = 0 time = 795
.meas tran vdout0_19ck158 FIND v(dout0_19) AT=795.025n

* CHECK dout0_20 Vdout0_20ck158 = 0 time = 795
.meas tran vdout0_20ck158 FIND v(dout0_20) AT=795.025n

* CHECK dout0_21 Vdout0_21ck158 = 1.1 time = 795
.meas tran vdout0_21ck158 FIND v(dout0_21) AT=795.025n

* CHECK dout0_22 Vdout0_22ck158 = 1.1 time = 795
.meas tran vdout0_22ck158 FIND v(dout0_22) AT=795.025n

* CHECK dout0_23 Vdout0_23ck158 = 0 time = 795
.meas tran vdout0_23ck158 FIND v(dout0_23) AT=795.025n

* CHECK dout0_24 Vdout0_24ck158 = 1.1 time = 795
.meas tran vdout0_24ck158 FIND v(dout0_24) AT=795.025n

* CHECK dout0_25 Vdout0_25ck158 = 1.1 time = 795
.meas tran vdout0_25ck158 FIND v(dout0_25) AT=795.025n

* CHECK dout0_26 Vdout0_26ck158 = 1.1 time = 795
.meas tran vdout0_26ck158 FIND v(dout0_26) AT=795.025n

* CHECK dout0_27 Vdout0_27ck158 = 1.1 time = 795
.meas tran vdout0_27ck158 FIND v(dout0_27) AT=795.025n

* CHECK dout0_28 Vdout0_28ck158 = 1.1 time = 795
.meas tran vdout0_28ck158 FIND v(dout0_28) AT=795.025n

* CHECK dout0_29 Vdout0_29ck158 = 0 time = 795
.meas tran vdout0_29ck158 FIND v(dout0_29) AT=795.025n

* CHECK dout0_30 Vdout0_30ck158 = 1.1 time = 795
.meas tran vdout0_30ck158 FIND v(dout0_30) AT=795.025n

* CHECK dout0_31 Vdout0_31ck158 = 0 time = 795
.meas tran vdout0_31ck158 FIND v(dout0_31) AT=795.025n

* CHECK dout0_0 Vdout0_0ck162 = 0 time = 815
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=815.025n

* CHECK dout0_1 Vdout0_1ck162 = 1.1 time = 815
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=815.025n

* CHECK dout0_2 Vdout0_2ck162 = 0 time = 815
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=815.025n

* CHECK dout0_3 Vdout0_3ck162 = 0 time = 815
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=815.025n

* CHECK dout0_4 Vdout0_4ck162 = 0 time = 815
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=815.025n

* CHECK dout0_5 Vdout0_5ck162 = 1.1 time = 815
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=815.025n

* CHECK dout0_6 Vdout0_6ck162 = 1.1 time = 815
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=815.025n

* CHECK dout0_7 Vdout0_7ck162 = 1.1 time = 815
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=815.025n

* CHECK dout0_8 Vdout0_8ck162 = 1.1 time = 815
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=815.025n

* CHECK dout0_9 Vdout0_9ck162 = 1.1 time = 815
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=815.025n

* CHECK dout0_10 Vdout0_10ck162 = 1.1 time = 815
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=815.025n

* CHECK dout0_11 Vdout0_11ck162 = 0 time = 815
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=815.025n

* CHECK dout0_12 Vdout0_12ck162 = 1.1 time = 815
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=815.025n

* CHECK dout0_13 Vdout0_13ck162 = 1.1 time = 815
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=815.025n

* CHECK dout0_14 Vdout0_14ck162 = 1.1 time = 815
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=815.025n

* CHECK dout0_15 Vdout0_15ck162 = 1.1 time = 815
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=815.025n

* CHECK dout0_16 Vdout0_16ck162 = 1.1 time = 815
.meas tran vdout0_16ck162 FIND v(dout0_16) AT=815.025n

* CHECK dout0_17 Vdout0_17ck162 = 1.1 time = 815
.meas tran vdout0_17ck162 FIND v(dout0_17) AT=815.025n

* CHECK dout0_18 Vdout0_18ck162 = 0 time = 815
.meas tran vdout0_18ck162 FIND v(dout0_18) AT=815.025n

* CHECK dout0_19 Vdout0_19ck162 = 0 time = 815
.meas tran vdout0_19ck162 FIND v(dout0_19) AT=815.025n

* CHECK dout0_20 Vdout0_20ck162 = 0 time = 815
.meas tran vdout0_20ck162 FIND v(dout0_20) AT=815.025n

* CHECK dout0_21 Vdout0_21ck162 = 1.1 time = 815
.meas tran vdout0_21ck162 FIND v(dout0_21) AT=815.025n

* CHECK dout0_22 Vdout0_22ck162 = 1.1 time = 815
.meas tran vdout0_22ck162 FIND v(dout0_22) AT=815.025n

* CHECK dout0_23 Vdout0_23ck162 = 0 time = 815
.meas tran vdout0_23ck162 FIND v(dout0_23) AT=815.025n

* CHECK dout0_24 Vdout0_24ck162 = 1.1 time = 815
.meas tran vdout0_24ck162 FIND v(dout0_24) AT=815.025n

* CHECK dout0_25 Vdout0_25ck162 = 1.1 time = 815
.meas tran vdout0_25ck162 FIND v(dout0_25) AT=815.025n

* CHECK dout0_26 Vdout0_26ck162 = 1.1 time = 815
.meas tran vdout0_26ck162 FIND v(dout0_26) AT=815.025n

* CHECK dout0_27 Vdout0_27ck162 = 1.1 time = 815
.meas tran vdout0_27ck162 FIND v(dout0_27) AT=815.025n

* CHECK dout0_28 Vdout0_28ck162 = 1.1 time = 815
.meas tran vdout0_28ck162 FIND v(dout0_28) AT=815.025n

* CHECK dout0_29 Vdout0_29ck162 = 0 time = 815
.meas tran vdout0_29ck162 FIND v(dout0_29) AT=815.025n

* CHECK dout0_30 Vdout0_30ck162 = 1.1 time = 815
.meas tran vdout0_30ck162 FIND v(dout0_30) AT=815.025n

* CHECK dout0_31 Vdout0_31ck162 = 0 time = 815
.meas tran vdout0_31ck162 FIND v(dout0_31) AT=815.025n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 830
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=830.025n

* CHECK dout0_1 Vdout0_1ck165 = 1.1 time = 830
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=830.025n

* CHECK dout0_2 Vdout0_2ck165 = 1.1 time = 830
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=830.025n

* CHECK dout0_3 Vdout0_3ck165 = 1.1 time = 830
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=830.025n

* CHECK dout0_4 Vdout0_4ck165 = 0 time = 830
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=830.025n

* CHECK dout0_5 Vdout0_5ck165 = 1.1 time = 830
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=830.025n

* CHECK dout0_6 Vdout0_6ck165 = 0 time = 830
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=830.025n

* CHECK dout0_7 Vdout0_7ck165 = 1.1 time = 830
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=830.025n

* CHECK dout0_8 Vdout0_8ck165 = 0 time = 830
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=830.025n

* CHECK dout0_9 Vdout0_9ck165 = 0 time = 830
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=830.025n

* CHECK dout0_10 Vdout0_10ck165 = 0 time = 830
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=830.025n

* CHECK dout0_11 Vdout0_11ck165 = 1.1 time = 830
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=830.025n

* CHECK dout0_12 Vdout0_12ck165 = 0 time = 830
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=830.025n

* CHECK dout0_13 Vdout0_13ck165 = 1.1 time = 830
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=830.025n

* CHECK dout0_14 Vdout0_14ck165 = 1.1 time = 830
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=830.025n

* CHECK dout0_15 Vdout0_15ck165 = 1.1 time = 830
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=830.025n

* CHECK dout0_16 Vdout0_16ck165 = 1.1 time = 830
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=830.025n

* CHECK dout0_17 Vdout0_17ck165 = 0 time = 830
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=830.025n

* CHECK dout0_18 Vdout0_18ck165 = 0 time = 830
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=830.025n

* CHECK dout0_19 Vdout0_19ck165 = 1.1 time = 830
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=830.025n

* CHECK dout0_20 Vdout0_20ck165 = 1.1 time = 830
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=830.025n

* CHECK dout0_21 Vdout0_21ck165 = 1.1 time = 830
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=830.025n

* CHECK dout0_22 Vdout0_22ck165 = 0 time = 830
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=830.025n

* CHECK dout0_23 Vdout0_23ck165 = 0 time = 830
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=830.025n

* CHECK dout0_24 Vdout0_24ck165 = 1.1 time = 830
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=830.025n

* CHECK dout0_25 Vdout0_25ck165 = 0 time = 830
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=830.025n

* CHECK dout0_26 Vdout0_26ck165 = 1.1 time = 830
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=830.025n

* CHECK dout0_27 Vdout0_27ck165 = 1.1 time = 830
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=830.025n

* CHECK dout0_28 Vdout0_28ck165 = 0 time = 830
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=830.025n

* CHECK dout0_29 Vdout0_29ck165 = 0 time = 830
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=830.025n

* CHECK dout0_30 Vdout0_30ck165 = 1.1 time = 830
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=830.025n

* CHECK dout0_31 Vdout0_31ck165 = 1.1 time = 830
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=830.025n

* CHECK dout0_0 Vdout0_0ck166 = 1.1 time = 835
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=835.025n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 835
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=835.025n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 835
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=835.025n

* CHECK dout0_3 Vdout0_3ck166 = 1.1 time = 835
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=835.025n

* CHECK dout0_4 Vdout0_4ck166 = 0 time = 835
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=835.025n

* CHECK dout0_5 Vdout0_5ck166 = 1.1 time = 835
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=835.025n

* CHECK dout0_6 Vdout0_6ck166 = 1.1 time = 835
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=835.025n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 835
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=835.025n

* CHECK dout0_8 Vdout0_8ck166 = 1.1 time = 835
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=835.025n

* CHECK dout0_9 Vdout0_9ck166 = 0 time = 835
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=835.025n

* CHECK dout0_10 Vdout0_10ck166 = 0 time = 835
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=835.025n

* CHECK dout0_11 Vdout0_11ck166 = 1.1 time = 835
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=835.025n

* CHECK dout0_12 Vdout0_12ck166 = 0 time = 835
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=835.025n

* CHECK dout0_13 Vdout0_13ck166 = 1.1 time = 835
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=835.025n

* CHECK dout0_14 Vdout0_14ck166 = 1.1 time = 835
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=835.025n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 835
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=835.025n

* CHECK dout0_16 Vdout0_16ck166 = 1.1 time = 835
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=835.025n

* CHECK dout0_17 Vdout0_17ck166 = 0 time = 835
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=835.025n

* CHECK dout0_18 Vdout0_18ck166 = 0 time = 835
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=835.025n

* CHECK dout0_19 Vdout0_19ck166 = 1.1 time = 835
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=835.025n

* CHECK dout0_20 Vdout0_20ck166 = 1.1 time = 835
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=835.025n

* CHECK dout0_21 Vdout0_21ck166 = 0 time = 835
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=835.025n

* CHECK dout0_22 Vdout0_22ck166 = 1.1 time = 835
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=835.025n

* CHECK dout0_23 Vdout0_23ck166 = 0 time = 835
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=835.025n

* CHECK dout0_24 Vdout0_24ck166 = 0 time = 835
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=835.025n

* CHECK dout0_25 Vdout0_25ck166 = 0 time = 835
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=835.025n

* CHECK dout0_26 Vdout0_26ck166 = 1.1 time = 835
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=835.025n

* CHECK dout0_27 Vdout0_27ck166 = 0 time = 835
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=835.025n

* CHECK dout0_28 Vdout0_28ck166 = 0 time = 835
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=835.025n

* CHECK dout0_29 Vdout0_29ck166 = 1.1 time = 835
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=835.025n

* CHECK dout0_30 Vdout0_30ck166 = 1.1 time = 835
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=835.025n

* CHECK dout0_31 Vdout0_31ck166 = 1.1 time = 835
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=835.025n

* CHECK dout0_0 Vdout0_0ck167 = 0 time = 840
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=840.025n

* CHECK dout0_1 Vdout0_1ck167 = 1.1 time = 840
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=840.025n

* CHECK dout0_2 Vdout0_2ck167 = 1.1 time = 840
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=840.025n

* CHECK dout0_3 Vdout0_3ck167 = 1.1 time = 840
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=840.025n

* CHECK dout0_4 Vdout0_4ck167 = 0 time = 840
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=840.025n

* CHECK dout0_5 Vdout0_5ck167 = 1.1 time = 840
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=840.025n

* CHECK dout0_6 Vdout0_6ck167 = 0 time = 840
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=840.025n

* CHECK dout0_7 Vdout0_7ck167 = 1.1 time = 840
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=840.025n

* CHECK dout0_8 Vdout0_8ck167 = 0 time = 840
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=840.025n

* CHECK dout0_9 Vdout0_9ck167 = 0 time = 840
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=840.025n

* CHECK dout0_10 Vdout0_10ck167 = 0 time = 840
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=840.025n

* CHECK dout0_11 Vdout0_11ck167 = 1.1 time = 840
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=840.025n

* CHECK dout0_12 Vdout0_12ck167 = 0 time = 840
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=840.025n

* CHECK dout0_13 Vdout0_13ck167 = 1.1 time = 840
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=840.025n

* CHECK dout0_14 Vdout0_14ck167 = 1.1 time = 840
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=840.025n

* CHECK dout0_15 Vdout0_15ck167 = 1.1 time = 840
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=840.025n

* CHECK dout0_16 Vdout0_16ck167 = 1.1 time = 840
.meas tran vdout0_16ck167 FIND v(dout0_16) AT=840.025n

* CHECK dout0_17 Vdout0_17ck167 = 0 time = 840
.meas tran vdout0_17ck167 FIND v(dout0_17) AT=840.025n

* CHECK dout0_18 Vdout0_18ck167 = 0 time = 840
.meas tran vdout0_18ck167 FIND v(dout0_18) AT=840.025n

* CHECK dout0_19 Vdout0_19ck167 = 1.1 time = 840
.meas tran vdout0_19ck167 FIND v(dout0_19) AT=840.025n

* CHECK dout0_20 Vdout0_20ck167 = 1.1 time = 840
.meas tran vdout0_20ck167 FIND v(dout0_20) AT=840.025n

* CHECK dout0_21 Vdout0_21ck167 = 1.1 time = 840
.meas tran vdout0_21ck167 FIND v(dout0_21) AT=840.025n

* CHECK dout0_22 Vdout0_22ck167 = 0 time = 840
.meas tran vdout0_22ck167 FIND v(dout0_22) AT=840.025n

* CHECK dout0_23 Vdout0_23ck167 = 0 time = 840
.meas tran vdout0_23ck167 FIND v(dout0_23) AT=840.025n

* CHECK dout0_24 Vdout0_24ck167 = 1.1 time = 840
.meas tran vdout0_24ck167 FIND v(dout0_24) AT=840.025n

* CHECK dout0_25 Vdout0_25ck167 = 0 time = 840
.meas tran vdout0_25ck167 FIND v(dout0_25) AT=840.025n

* CHECK dout0_26 Vdout0_26ck167 = 1.1 time = 840
.meas tran vdout0_26ck167 FIND v(dout0_26) AT=840.025n

* CHECK dout0_27 Vdout0_27ck167 = 1.1 time = 840
.meas tran vdout0_27ck167 FIND v(dout0_27) AT=840.025n

* CHECK dout0_28 Vdout0_28ck167 = 0 time = 840
.meas tran vdout0_28ck167 FIND v(dout0_28) AT=840.025n

* CHECK dout0_29 Vdout0_29ck167 = 0 time = 840
.meas tran vdout0_29ck167 FIND v(dout0_29) AT=840.025n

* CHECK dout0_30 Vdout0_30ck167 = 1.1 time = 840
.meas tran vdout0_30ck167 FIND v(dout0_30) AT=840.025n

* CHECK dout0_31 Vdout0_31ck167 = 1.1 time = 840
.meas tran vdout0_31ck167 FIND v(dout0_31) AT=840.025n

* CHECK dout0_0 Vdout0_0ck170 = 0 time = 855
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=855.025n

* CHECK dout0_1 Vdout0_1ck170 = 1.1 time = 855
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=855.025n

* CHECK dout0_2 Vdout0_2ck170 = 1.1 time = 855
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=855.025n

* CHECK dout0_3 Vdout0_3ck170 = 1.1 time = 855
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=855.025n

* CHECK dout0_4 Vdout0_4ck170 = 1.1 time = 855
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=855.025n

* CHECK dout0_5 Vdout0_5ck170 = 1.1 time = 855
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=855.025n

* CHECK dout0_6 Vdout0_6ck170 = 1.1 time = 855
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=855.025n

* CHECK dout0_7 Vdout0_7ck170 = 1.1 time = 855
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=855.025n

* CHECK dout0_8 Vdout0_8ck170 = 0 time = 855
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=855.025n

* CHECK dout0_9 Vdout0_9ck170 = 0 time = 855
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=855.025n

* CHECK dout0_10 Vdout0_10ck170 = 0 time = 855
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=855.025n

* CHECK dout0_11 Vdout0_11ck170 = 0 time = 855
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=855.025n

* CHECK dout0_12 Vdout0_12ck170 = 1.1 time = 855
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=855.025n

* CHECK dout0_13 Vdout0_13ck170 = 0 time = 855
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=855.025n

* CHECK dout0_14 Vdout0_14ck170 = 1.1 time = 855
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=855.025n

* CHECK dout0_15 Vdout0_15ck170 = 0 time = 855
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=855.025n

* CHECK dout0_16 Vdout0_16ck170 = 1.1 time = 855
.meas tran vdout0_16ck170 FIND v(dout0_16) AT=855.025n

* CHECK dout0_17 Vdout0_17ck170 = 0 time = 855
.meas tran vdout0_17ck170 FIND v(dout0_17) AT=855.025n

* CHECK dout0_18 Vdout0_18ck170 = 0 time = 855
.meas tran vdout0_18ck170 FIND v(dout0_18) AT=855.025n

* CHECK dout0_19 Vdout0_19ck170 = 1.1 time = 855
.meas tran vdout0_19ck170 FIND v(dout0_19) AT=855.025n

* CHECK dout0_20 Vdout0_20ck170 = 0 time = 855
.meas tran vdout0_20ck170 FIND v(dout0_20) AT=855.025n

* CHECK dout0_21 Vdout0_21ck170 = 1.1 time = 855
.meas tran vdout0_21ck170 FIND v(dout0_21) AT=855.025n

* CHECK dout0_22 Vdout0_22ck170 = 0 time = 855
.meas tran vdout0_22ck170 FIND v(dout0_22) AT=855.025n

* CHECK dout0_23 Vdout0_23ck170 = 1.1 time = 855
.meas tran vdout0_23ck170 FIND v(dout0_23) AT=855.025n

* CHECK dout0_24 Vdout0_24ck170 = 0 time = 855
.meas tran vdout0_24ck170 FIND v(dout0_24) AT=855.025n

* CHECK dout0_25 Vdout0_25ck170 = 1.1 time = 855
.meas tran vdout0_25ck170 FIND v(dout0_25) AT=855.025n

* CHECK dout0_26 Vdout0_26ck170 = 1.1 time = 855
.meas tran vdout0_26ck170 FIND v(dout0_26) AT=855.025n

* CHECK dout0_27 Vdout0_27ck170 = 1.1 time = 855
.meas tran vdout0_27ck170 FIND v(dout0_27) AT=855.025n

* CHECK dout0_28 Vdout0_28ck170 = 0 time = 855
.meas tran vdout0_28ck170 FIND v(dout0_28) AT=855.025n

* CHECK dout0_29 Vdout0_29ck170 = 0 time = 855
.meas tran vdout0_29ck170 FIND v(dout0_29) AT=855.025n

* CHECK dout0_30 Vdout0_30ck170 = 0 time = 855
.meas tran vdout0_30ck170 FIND v(dout0_30) AT=855.025n

* CHECK dout0_31 Vdout0_31ck170 = 0 time = 855
.meas tran vdout0_31ck170 FIND v(dout0_31) AT=855.025n

* CHECK dout0_0 Vdout0_0ck171 = 0 time = 860
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=860.025n

* CHECK dout0_1 Vdout0_1ck171 = 1.1 time = 860
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=860.025n

* CHECK dout0_2 Vdout0_2ck171 = 0 time = 860
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=860.025n

* CHECK dout0_3 Vdout0_3ck171 = 1.1 time = 860
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=860.025n

* CHECK dout0_4 Vdout0_4ck171 = 1.1 time = 860
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=860.025n

* CHECK dout0_5 Vdout0_5ck171 = 1.1 time = 860
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=860.025n

* CHECK dout0_6 Vdout0_6ck171 = 1.1 time = 860
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=860.025n

* CHECK dout0_7 Vdout0_7ck171 = 0 time = 860
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=860.025n

* CHECK dout0_8 Vdout0_8ck171 = 1.1 time = 860
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=860.025n

* CHECK dout0_9 Vdout0_9ck171 = 1.1 time = 860
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=860.025n

* CHECK dout0_10 Vdout0_10ck171 = 0 time = 860
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=860.025n

* CHECK dout0_11 Vdout0_11ck171 = 1.1 time = 860
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=860.025n

* CHECK dout0_12 Vdout0_12ck171 = 0 time = 860
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=860.025n

* CHECK dout0_13 Vdout0_13ck171 = 1.1 time = 860
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=860.025n

* CHECK dout0_14 Vdout0_14ck171 = 0 time = 860
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=860.025n

* CHECK dout0_15 Vdout0_15ck171 = 0 time = 860
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=860.025n

* CHECK dout0_16 Vdout0_16ck171 = 1.1 time = 860
.meas tran vdout0_16ck171 FIND v(dout0_16) AT=860.025n

* CHECK dout0_17 Vdout0_17ck171 = 0 time = 860
.meas tran vdout0_17ck171 FIND v(dout0_17) AT=860.025n

* CHECK dout0_18 Vdout0_18ck171 = 0 time = 860
.meas tran vdout0_18ck171 FIND v(dout0_18) AT=860.025n

* CHECK dout0_19 Vdout0_19ck171 = 1.1 time = 860
.meas tran vdout0_19ck171 FIND v(dout0_19) AT=860.025n

* CHECK dout0_20 Vdout0_20ck171 = 0 time = 860
.meas tran vdout0_20ck171 FIND v(dout0_20) AT=860.025n

* CHECK dout0_21 Vdout0_21ck171 = 0 time = 860
.meas tran vdout0_21ck171 FIND v(dout0_21) AT=860.025n

* CHECK dout0_22 Vdout0_22ck171 = 0 time = 860
.meas tran vdout0_22ck171 FIND v(dout0_22) AT=860.025n

* CHECK dout0_23 Vdout0_23ck171 = 0 time = 860
.meas tran vdout0_23ck171 FIND v(dout0_23) AT=860.025n

* CHECK dout0_24 Vdout0_24ck171 = 0 time = 860
.meas tran vdout0_24ck171 FIND v(dout0_24) AT=860.025n

* CHECK dout0_25 Vdout0_25ck171 = 1.1 time = 860
.meas tran vdout0_25ck171 FIND v(dout0_25) AT=860.025n

* CHECK dout0_26 Vdout0_26ck171 = 1.1 time = 860
.meas tran vdout0_26ck171 FIND v(dout0_26) AT=860.025n

* CHECK dout0_27 Vdout0_27ck171 = 1.1 time = 860
.meas tran vdout0_27ck171 FIND v(dout0_27) AT=860.025n

* CHECK dout0_28 Vdout0_28ck171 = 0 time = 860
.meas tran vdout0_28ck171 FIND v(dout0_28) AT=860.025n

* CHECK dout0_29 Vdout0_29ck171 = 0 time = 860
.meas tran vdout0_29ck171 FIND v(dout0_29) AT=860.025n

* CHECK dout0_30 Vdout0_30ck171 = 1.1 time = 860
.meas tran vdout0_30ck171 FIND v(dout0_30) AT=860.025n

* CHECK dout0_31 Vdout0_31ck171 = 0 time = 860
.meas tran vdout0_31ck171 FIND v(dout0_31) AT=860.025n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 865
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=865.025n

* CHECK dout0_1 Vdout0_1ck172 = 1.1 time = 865
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=865.025n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 865
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=865.025n

* CHECK dout0_3 Vdout0_3ck172 = 1.1 time = 865
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=865.025n

* CHECK dout0_4 Vdout0_4ck172 = 1.1 time = 865
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=865.025n

* CHECK dout0_5 Vdout0_5ck172 = 1.1 time = 865
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=865.025n

* CHECK dout0_6 Vdout0_6ck172 = 1.1 time = 865
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=865.025n

* CHECK dout0_7 Vdout0_7ck172 = 0 time = 865
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=865.025n

* CHECK dout0_8 Vdout0_8ck172 = 1.1 time = 865
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=865.025n

* CHECK dout0_9 Vdout0_9ck172 = 1.1 time = 865
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=865.025n

* CHECK dout0_10 Vdout0_10ck172 = 0 time = 865
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=865.025n

* CHECK dout0_11 Vdout0_11ck172 = 1.1 time = 865
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=865.025n

* CHECK dout0_12 Vdout0_12ck172 = 0 time = 865
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=865.025n

* CHECK dout0_13 Vdout0_13ck172 = 1.1 time = 865
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=865.025n

* CHECK dout0_14 Vdout0_14ck172 = 0 time = 865
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=865.025n

* CHECK dout0_15 Vdout0_15ck172 = 0 time = 865
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=865.025n

* CHECK dout0_16 Vdout0_16ck172 = 1.1 time = 865
.meas tran vdout0_16ck172 FIND v(dout0_16) AT=865.025n

* CHECK dout0_17 Vdout0_17ck172 = 0 time = 865
.meas tran vdout0_17ck172 FIND v(dout0_17) AT=865.025n

* CHECK dout0_18 Vdout0_18ck172 = 0 time = 865
.meas tran vdout0_18ck172 FIND v(dout0_18) AT=865.025n

* CHECK dout0_19 Vdout0_19ck172 = 1.1 time = 865
.meas tran vdout0_19ck172 FIND v(dout0_19) AT=865.025n

* CHECK dout0_20 Vdout0_20ck172 = 0 time = 865
.meas tran vdout0_20ck172 FIND v(dout0_20) AT=865.025n

* CHECK dout0_21 Vdout0_21ck172 = 0 time = 865
.meas tran vdout0_21ck172 FIND v(dout0_21) AT=865.025n

* CHECK dout0_22 Vdout0_22ck172 = 0 time = 865
.meas tran vdout0_22ck172 FIND v(dout0_22) AT=865.025n

* CHECK dout0_23 Vdout0_23ck172 = 0 time = 865
.meas tran vdout0_23ck172 FIND v(dout0_23) AT=865.025n

* CHECK dout0_24 Vdout0_24ck172 = 0 time = 865
.meas tran vdout0_24ck172 FIND v(dout0_24) AT=865.025n

* CHECK dout0_25 Vdout0_25ck172 = 1.1 time = 865
.meas tran vdout0_25ck172 FIND v(dout0_25) AT=865.025n

* CHECK dout0_26 Vdout0_26ck172 = 1.1 time = 865
.meas tran vdout0_26ck172 FIND v(dout0_26) AT=865.025n

* CHECK dout0_27 Vdout0_27ck172 = 1.1 time = 865
.meas tran vdout0_27ck172 FIND v(dout0_27) AT=865.025n

* CHECK dout0_28 Vdout0_28ck172 = 0 time = 865
.meas tran vdout0_28ck172 FIND v(dout0_28) AT=865.025n

* CHECK dout0_29 Vdout0_29ck172 = 0 time = 865
.meas tran vdout0_29ck172 FIND v(dout0_29) AT=865.025n

* CHECK dout0_30 Vdout0_30ck172 = 1.1 time = 865
.meas tran vdout0_30ck172 FIND v(dout0_30) AT=865.025n

* CHECK dout0_31 Vdout0_31ck172 = 0 time = 865
.meas tran vdout0_31ck172 FIND v(dout0_31) AT=865.025n

* CHECK dout0_0 Vdout0_0ck173 = 0 time = 870
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=870.025n

* CHECK dout0_1 Vdout0_1ck173 = 0 time = 870
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=870.025n

* CHECK dout0_2 Vdout0_2ck173 = 1.1 time = 870
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=870.025n

* CHECK dout0_3 Vdout0_3ck173 = 1.1 time = 870
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=870.025n

* CHECK dout0_4 Vdout0_4ck173 = 0 time = 870
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=870.025n

* CHECK dout0_5 Vdout0_5ck173 = 0 time = 870
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=870.025n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 870
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=870.025n

* CHECK dout0_7 Vdout0_7ck173 = 0 time = 870
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=870.025n

* CHECK dout0_8 Vdout0_8ck173 = 0 time = 870
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=870.025n

* CHECK dout0_9 Vdout0_9ck173 = 0 time = 870
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=870.025n

* CHECK dout0_10 Vdout0_10ck173 = 0 time = 870
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=870.025n

* CHECK dout0_11 Vdout0_11ck173 = 0 time = 870
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=870.025n

* CHECK dout0_12 Vdout0_12ck173 = 1.1 time = 870
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=870.025n

* CHECK dout0_13 Vdout0_13ck173 = 1.1 time = 870
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=870.025n

* CHECK dout0_14 Vdout0_14ck173 = 0 time = 870
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=870.025n

* CHECK dout0_15 Vdout0_15ck173 = 1.1 time = 870
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=870.025n

* CHECK dout0_16 Vdout0_16ck173 = 0 time = 870
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=870.025n

* CHECK dout0_17 Vdout0_17ck173 = 0 time = 870
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=870.025n

* CHECK dout0_18 Vdout0_18ck173 = 1.1 time = 870
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=870.025n

* CHECK dout0_19 Vdout0_19ck173 = 1.1 time = 870
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=870.025n

* CHECK dout0_20 Vdout0_20ck173 = 0 time = 870
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=870.025n

* CHECK dout0_21 Vdout0_21ck173 = 0 time = 870
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=870.025n

* CHECK dout0_22 Vdout0_22ck173 = 0 time = 870
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=870.025n

* CHECK dout0_23 Vdout0_23ck173 = 0 time = 870
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=870.025n

* CHECK dout0_24 Vdout0_24ck173 = 1.1 time = 870
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=870.025n

* CHECK dout0_25 Vdout0_25ck173 = 1.1 time = 870
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=870.025n

* CHECK dout0_26 Vdout0_26ck173 = 1.1 time = 870
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=870.025n

* CHECK dout0_27 Vdout0_27ck173 = 0 time = 870
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=870.025n

* CHECK dout0_28 Vdout0_28ck173 = 1.1 time = 870
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=870.025n

* CHECK dout0_29 Vdout0_29ck173 = 0 time = 870
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=870.025n

* CHECK dout0_30 Vdout0_30ck173 = 0 time = 870
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=870.025n

* CHECK dout0_31 Vdout0_31ck173 = 1.1 time = 870
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=870.025n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 875
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=875.025n

* CHECK dout0_1 Vdout0_1ck174 = 1.1 time = 875
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=875.025n

* CHECK dout0_2 Vdout0_2ck174 = 1.1 time = 875
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=875.025n

* CHECK dout0_3 Vdout0_3ck174 = 1.1 time = 875
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=875.025n

* CHECK dout0_4 Vdout0_4ck174 = 0 time = 875
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=875.025n

* CHECK dout0_5 Vdout0_5ck174 = 1.1 time = 875
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=875.025n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 875
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=875.025n

* CHECK dout0_7 Vdout0_7ck174 = 1.1 time = 875
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=875.025n

* CHECK dout0_8 Vdout0_8ck174 = 0 time = 875
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=875.025n

* CHECK dout0_9 Vdout0_9ck174 = 0 time = 875
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=875.025n

* CHECK dout0_10 Vdout0_10ck174 = 0 time = 875
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=875.025n

* CHECK dout0_11 Vdout0_11ck174 = 1.1 time = 875
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=875.025n

* CHECK dout0_12 Vdout0_12ck174 = 0 time = 875
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=875.025n

* CHECK dout0_13 Vdout0_13ck174 = 1.1 time = 875
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=875.025n

* CHECK dout0_14 Vdout0_14ck174 = 1.1 time = 875
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=875.025n

* CHECK dout0_15 Vdout0_15ck174 = 1.1 time = 875
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=875.025n

* CHECK dout0_16 Vdout0_16ck174 = 1.1 time = 875
.meas tran vdout0_16ck174 FIND v(dout0_16) AT=875.025n

* CHECK dout0_17 Vdout0_17ck174 = 0 time = 875
.meas tran vdout0_17ck174 FIND v(dout0_17) AT=875.025n

* CHECK dout0_18 Vdout0_18ck174 = 0 time = 875
.meas tran vdout0_18ck174 FIND v(dout0_18) AT=875.025n

* CHECK dout0_19 Vdout0_19ck174 = 1.1 time = 875
.meas tran vdout0_19ck174 FIND v(dout0_19) AT=875.025n

* CHECK dout0_20 Vdout0_20ck174 = 1.1 time = 875
.meas tran vdout0_20ck174 FIND v(dout0_20) AT=875.025n

* CHECK dout0_21 Vdout0_21ck174 = 1.1 time = 875
.meas tran vdout0_21ck174 FIND v(dout0_21) AT=875.025n

* CHECK dout0_22 Vdout0_22ck174 = 0 time = 875
.meas tran vdout0_22ck174 FIND v(dout0_22) AT=875.025n

* CHECK dout0_23 Vdout0_23ck174 = 0 time = 875
.meas tran vdout0_23ck174 FIND v(dout0_23) AT=875.025n

* CHECK dout0_24 Vdout0_24ck174 = 1.1 time = 875
.meas tran vdout0_24ck174 FIND v(dout0_24) AT=875.025n

* CHECK dout0_25 Vdout0_25ck174 = 0 time = 875
.meas tran vdout0_25ck174 FIND v(dout0_25) AT=875.025n

* CHECK dout0_26 Vdout0_26ck174 = 1.1 time = 875
.meas tran vdout0_26ck174 FIND v(dout0_26) AT=875.025n

* CHECK dout0_27 Vdout0_27ck174 = 1.1 time = 875
.meas tran vdout0_27ck174 FIND v(dout0_27) AT=875.025n

* CHECK dout0_28 Vdout0_28ck174 = 0 time = 875
.meas tran vdout0_28ck174 FIND v(dout0_28) AT=875.025n

* CHECK dout0_29 Vdout0_29ck174 = 0 time = 875
.meas tran vdout0_29ck174 FIND v(dout0_29) AT=875.025n

* CHECK dout0_30 Vdout0_30ck174 = 1.1 time = 875
.meas tran vdout0_30ck174 FIND v(dout0_30) AT=875.025n

* CHECK dout0_31 Vdout0_31ck174 = 1.1 time = 875
.meas tran vdout0_31ck174 FIND v(dout0_31) AT=875.025n

* CHECK dout0_0 Vdout0_0ck176 = 0 time = 885
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=885.025n

* CHECK dout0_1 Vdout0_1ck176 = 1.1 time = 885
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=885.025n

* CHECK dout0_2 Vdout0_2ck176 = 0 time = 885
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=885.025n

* CHECK dout0_3 Vdout0_3ck176 = 1.1 time = 885
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=885.025n

* CHECK dout0_4 Vdout0_4ck176 = 1.1 time = 885
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=885.025n

* CHECK dout0_5 Vdout0_5ck176 = 1.1 time = 885
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=885.025n

* CHECK dout0_6 Vdout0_6ck176 = 1.1 time = 885
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=885.025n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 885
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=885.025n

* CHECK dout0_8 Vdout0_8ck176 = 1.1 time = 885
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=885.025n

* CHECK dout0_9 Vdout0_9ck176 = 1.1 time = 885
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=885.025n

* CHECK dout0_10 Vdout0_10ck176 = 0 time = 885
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=885.025n

* CHECK dout0_11 Vdout0_11ck176 = 1.1 time = 885
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=885.025n

* CHECK dout0_12 Vdout0_12ck176 = 0 time = 885
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=885.025n

* CHECK dout0_13 Vdout0_13ck176 = 1.1 time = 885
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=885.025n

* CHECK dout0_14 Vdout0_14ck176 = 0 time = 885
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=885.025n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 885
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=885.025n

* CHECK dout0_16 Vdout0_16ck176 = 1.1 time = 885
.meas tran vdout0_16ck176 FIND v(dout0_16) AT=885.025n

* CHECK dout0_17 Vdout0_17ck176 = 0 time = 885
.meas tran vdout0_17ck176 FIND v(dout0_17) AT=885.025n

* CHECK dout0_18 Vdout0_18ck176 = 0 time = 885
.meas tran vdout0_18ck176 FIND v(dout0_18) AT=885.025n

* CHECK dout0_19 Vdout0_19ck176 = 1.1 time = 885
.meas tran vdout0_19ck176 FIND v(dout0_19) AT=885.025n

* CHECK dout0_20 Vdout0_20ck176 = 0 time = 885
.meas tran vdout0_20ck176 FIND v(dout0_20) AT=885.025n

* CHECK dout0_21 Vdout0_21ck176 = 0 time = 885
.meas tran vdout0_21ck176 FIND v(dout0_21) AT=885.025n

* CHECK dout0_22 Vdout0_22ck176 = 0 time = 885
.meas tran vdout0_22ck176 FIND v(dout0_22) AT=885.025n

* CHECK dout0_23 Vdout0_23ck176 = 0 time = 885
.meas tran vdout0_23ck176 FIND v(dout0_23) AT=885.025n

* CHECK dout0_24 Vdout0_24ck176 = 0 time = 885
.meas tran vdout0_24ck176 FIND v(dout0_24) AT=885.025n

* CHECK dout0_25 Vdout0_25ck176 = 1.1 time = 885
.meas tran vdout0_25ck176 FIND v(dout0_25) AT=885.025n

* CHECK dout0_26 Vdout0_26ck176 = 1.1 time = 885
.meas tran vdout0_26ck176 FIND v(dout0_26) AT=885.025n

* CHECK dout0_27 Vdout0_27ck176 = 1.1 time = 885
.meas tran vdout0_27ck176 FIND v(dout0_27) AT=885.025n

* CHECK dout0_28 Vdout0_28ck176 = 0 time = 885
.meas tran vdout0_28ck176 FIND v(dout0_28) AT=885.025n

* CHECK dout0_29 Vdout0_29ck176 = 0 time = 885
.meas tran vdout0_29ck176 FIND v(dout0_29) AT=885.025n

* CHECK dout0_30 Vdout0_30ck176 = 1.1 time = 885
.meas tran vdout0_30ck176 FIND v(dout0_30) AT=885.025n

* CHECK dout0_31 Vdout0_31ck176 = 0 time = 885
.meas tran vdout0_31ck176 FIND v(dout0_31) AT=885.025n

* CHECK dout0_0 Vdout0_0ck178 = 0 time = 895
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=895.025n

* CHECK dout0_1 Vdout0_1ck178 = 1.1 time = 895
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=895.025n

* CHECK dout0_2 Vdout0_2ck178 = 0 time = 895
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=895.025n

* CHECK dout0_3 Vdout0_3ck178 = 1.1 time = 895
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=895.025n

* CHECK dout0_4 Vdout0_4ck178 = 1.1 time = 895
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=895.025n

* CHECK dout0_5 Vdout0_5ck178 = 1.1 time = 895
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=895.025n

* CHECK dout0_6 Vdout0_6ck178 = 1.1 time = 895
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=895.025n

* CHECK dout0_7 Vdout0_7ck178 = 0 time = 895
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=895.025n

* CHECK dout0_8 Vdout0_8ck178 = 1.1 time = 895
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=895.025n

* CHECK dout0_9 Vdout0_9ck178 = 1.1 time = 895
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=895.025n

* CHECK dout0_10 Vdout0_10ck178 = 0 time = 895
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=895.025n

* CHECK dout0_11 Vdout0_11ck178 = 1.1 time = 895
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=895.025n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 895
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=895.025n

* CHECK dout0_13 Vdout0_13ck178 = 1.1 time = 895
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=895.025n

* CHECK dout0_14 Vdout0_14ck178 = 0 time = 895
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=895.025n

* CHECK dout0_15 Vdout0_15ck178 = 0 time = 895
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=895.025n

* CHECK dout0_16 Vdout0_16ck178 = 1.1 time = 895
.meas tran vdout0_16ck178 FIND v(dout0_16) AT=895.025n

* CHECK dout0_17 Vdout0_17ck178 = 0 time = 895
.meas tran vdout0_17ck178 FIND v(dout0_17) AT=895.025n

* CHECK dout0_18 Vdout0_18ck178 = 0 time = 895
.meas tran vdout0_18ck178 FIND v(dout0_18) AT=895.025n

* CHECK dout0_19 Vdout0_19ck178 = 1.1 time = 895
.meas tran vdout0_19ck178 FIND v(dout0_19) AT=895.025n

* CHECK dout0_20 Vdout0_20ck178 = 0 time = 895
.meas tran vdout0_20ck178 FIND v(dout0_20) AT=895.025n

* CHECK dout0_21 Vdout0_21ck178 = 0 time = 895
.meas tran vdout0_21ck178 FIND v(dout0_21) AT=895.025n

* CHECK dout0_22 Vdout0_22ck178 = 0 time = 895
.meas tran vdout0_22ck178 FIND v(dout0_22) AT=895.025n

* CHECK dout0_23 Vdout0_23ck178 = 0 time = 895
.meas tran vdout0_23ck178 FIND v(dout0_23) AT=895.025n

* CHECK dout0_24 Vdout0_24ck178 = 0 time = 895
.meas tran vdout0_24ck178 FIND v(dout0_24) AT=895.025n

* CHECK dout0_25 Vdout0_25ck178 = 1.1 time = 895
.meas tran vdout0_25ck178 FIND v(dout0_25) AT=895.025n

* CHECK dout0_26 Vdout0_26ck178 = 1.1 time = 895
.meas tran vdout0_26ck178 FIND v(dout0_26) AT=895.025n

* CHECK dout0_27 Vdout0_27ck178 = 1.1 time = 895
.meas tran vdout0_27ck178 FIND v(dout0_27) AT=895.025n

* CHECK dout0_28 Vdout0_28ck178 = 0 time = 895
.meas tran vdout0_28ck178 FIND v(dout0_28) AT=895.025n

* CHECK dout0_29 Vdout0_29ck178 = 0 time = 895
.meas tran vdout0_29ck178 FIND v(dout0_29) AT=895.025n

* CHECK dout0_30 Vdout0_30ck178 = 1.1 time = 895
.meas tran vdout0_30ck178 FIND v(dout0_30) AT=895.025n

* CHECK dout0_31 Vdout0_31ck178 = 0 time = 895
.meas tran vdout0_31ck178 FIND v(dout0_31) AT=895.025n

* CHECK dout0_0 Vdout0_0ck184 = 0 time = 925
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=925.025n

* CHECK dout0_1 Vdout0_1ck184 = 0 time = 925
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=925.025n

* CHECK dout0_2 Vdout0_2ck184 = 1.1 time = 925
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=925.025n

* CHECK dout0_3 Vdout0_3ck184 = 1.1 time = 925
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=925.025n

* CHECK dout0_4 Vdout0_4ck184 = 0 time = 925
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=925.025n

* CHECK dout0_5 Vdout0_5ck184 = 1.1 time = 925
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=925.025n

* CHECK dout0_6 Vdout0_6ck184 = 0 time = 925
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=925.025n

* CHECK dout0_7 Vdout0_7ck184 = 0 time = 925
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=925.025n

* CHECK dout0_8 Vdout0_8ck184 = 1.1 time = 925
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=925.025n

* CHECK dout0_9 Vdout0_9ck184 = 0 time = 925
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=925.025n

* CHECK dout0_10 Vdout0_10ck184 = 0 time = 925
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=925.025n

* CHECK dout0_11 Vdout0_11ck184 = 0 time = 925
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=925.025n

* CHECK dout0_12 Vdout0_12ck184 = 1.1 time = 925
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=925.025n

* CHECK dout0_13 Vdout0_13ck184 = 1.1 time = 925
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=925.025n

* CHECK dout0_14 Vdout0_14ck184 = 1.1 time = 925
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=925.025n

* CHECK dout0_15 Vdout0_15ck184 = 0 time = 925
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=925.025n

* CHECK dout0_16 Vdout0_16ck184 = 0 time = 925
.meas tran vdout0_16ck184 FIND v(dout0_16) AT=925.025n

* CHECK dout0_17 Vdout0_17ck184 = 0 time = 925
.meas tran vdout0_17ck184 FIND v(dout0_17) AT=925.025n

* CHECK dout0_18 Vdout0_18ck184 = 1.1 time = 925
.meas tran vdout0_18ck184 FIND v(dout0_18) AT=925.025n

* CHECK dout0_19 Vdout0_19ck184 = 1.1 time = 925
.meas tran vdout0_19ck184 FIND v(dout0_19) AT=925.025n

* CHECK dout0_20 Vdout0_20ck184 = 1.1 time = 925
.meas tran vdout0_20ck184 FIND v(dout0_20) AT=925.025n

* CHECK dout0_21 Vdout0_21ck184 = 1.1 time = 925
.meas tran vdout0_21ck184 FIND v(dout0_21) AT=925.025n

* CHECK dout0_22 Vdout0_22ck184 = 1.1 time = 925
.meas tran vdout0_22ck184 FIND v(dout0_22) AT=925.025n

* CHECK dout0_23 Vdout0_23ck184 = 0 time = 925
.meas tran vdout0_23ck184 FIND v(dout0_23) AT=925.025n

* CHECK dout0_24 Vdout0_24ck184 = 1.1 time = 925
.meas tran vdout0_24ck184 FIND v(dout0_24) AT=925.025n

* CHECK dout0_25 Vdout0_25ck184 = 1.1 time = 925
.meas tran vdout0_25ck184 FIND v(dout0_25) AT=925.025n

* CHECK dout0_26 Vdout0_26ck184 = 0 time = 925
.meas tran vdout0_26ck184 FIND v(dout0_26) AT=925.025n

* CHECK dout0_27 Vdout0_27ck184 = 0 time = 925
.meas tran vdout0_27ck184 FIND v(dout0_27) AT=925.025n

* CHECK dout0_28 Vdout0_28ck184 = 1.1 time = 925
.meas tran vdout0_28ck184 FIND v(dout0_28) AT=925.025n

* CHECK dout0_29 Vdout0_29ck184 = 0 time = 925
.meas tran vdout0_29ck184 FIND v(dout0_29) AT=925.025n

* CHECK dout0_30 Vdout0_30ck184 = 1.1 time = 925
.meas tran vdout0_30ck184 FIND v(dout0_30) AT=925.025n

* CHECK dout0_31 Vdout0_31ck184 = 1.1 time = 925
.meas tran vdout0_31ck184 FIND v(dout0_31) AT=925.025n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 965
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=965.025n

* CHECK dout0_1 Vdout0_1ck192 = 1.1 time = 965
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=965.025n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 965
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=965.025n

* CHECK dout0_3 Vdout0_3ck192 = 1.1 time = 965
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=965.025n

* CHECK dout0_4 Vdout0_4ck192 = 1.1 time = 965
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=965.025n

* CHECK dout0_5 Vdout0_5ck192 = 1.1 time = 965
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=965.025n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 965
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=965.025n

* CHECK dout0_7 Vdout0_7ck192 = 0 time = 965
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=965.025n

* CHECK dout0_8 Vdout0_8ck192 = 0 time = 965
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=965.025n

* CHECK dout0_9 Vdout0_9ck192 = 0 time = 965
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=965.025n

* CHECK dout0_10 Vdout0_10ck192 = 1.1 time = 965
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=965.025n

* CHECK dout0_11 Vdout0_11ck192 = 1.1 time = 965
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=965.025n

* CHECK dout0_12 Vdout0_12ck192 = 1.1 time = 965
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=965.025n

* CHECK dout0_13 Vdout0_13ck192 = 1.1 time = 965
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=965.025n

* CHECK dout0_14 Vdout0_14ck192 = 0 time = 965
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=965.025n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 965
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=965.025n

* CHECK dout0_16 Vdout0_16ck192 = 1.1 time = 965
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=965.025n

* CHECK dout0_17 Vdout0_17ck192 = 0 time = 965
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=965.025n

* CHECK dout0_18 Vdout0_18ck192 = 1.1 time = 965
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=965.025n

* CHECK dout0_19 Vdout0_19ck192 = 1.1 time = 965
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=965.025n

* CHECK dout0_20 Vdout0_20ck192 = 1.1 time = 965
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=965.025n

* CHECK dout0_21 Vdout0_21ck192 = 1.1 time = 965
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=965.025n

* CHECK dout0_22 Vdout0_22ck192 = 1.1 time = 965
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=965.025n

* CHECK dout0_23 Vdout0_23ck192 = 0 time = 965
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=965.025n

* CHECK dout0_24 Vdout0_24ck192 = 0 time = 965
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=965.025n

* CHECK dout0_25 Vdout0_25ck192 = 0 time = 965
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=965.025n

* CHECK dout0_26 Vdout0_26ck192 = 0 time = 965
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=965.025n

* CHECK dout0_27 Vdout0_27ck192 = 0 time = 965
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=965.025n

* CHECK dout0_28 Vdout0_28ck192 = 0 time = 965
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=965.025n

* CHECK dout0_29 Vdout0_29ck192 = 1.1 time = 965
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=965.025n

* CHECK dout0_30 Vdout0_30ck192 = 0 time = 965
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=965.025n

* CHECK dout0_31 Vdout0_31ck192 = 1.1 time = 965
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=965.025n

* CHECK dout0_0 Vdout0_0ck193 = 0 time = 970
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=970.025n

* CHECK dout0_1 Vdout0_1ck193 = 1.1 time = 970
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=970.025n

* CHECK dout0_2 Vdout0_2ck193 = 0 time = 970
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=970.025n

* CHECK dout0_3 Vdout0_3ck193 = 1.1 time = 970
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=970.025n

* CHECK dout0_4 Vdout0_4ck193 = 1.1 time = 970
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=970.025n

* CHECK dout0_5 Vdout0_5ck193 = 1.1 time = 970
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=970.025n

* CHECK dout0_6 Vdout0_6ck193 = 0 time = 970
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=970.025n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 970
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=970.025n

* CHECK dout0_8 Vdout0_8ck193 = 0 time = 970
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=970.025n

* CHECK dout0_9 Vdout0_9ck193 = 0 time = 970
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=970.025n

* CHECK dout0_10 Vdout0_10ck193 = 1.1 time = 970
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=970.025n

* CHECK dout0_11 Vdout0_11ck193 = 1.1 time = 970
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=970.025n

* CHECK dout0_12 Vdout0_12ck193 = 1.1 time = 970
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=970.025n

* CHECK dout0_13 Vdout0_13ck193 = 1.1 time = 970
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=970.025n

* CHECK dout0_14 Vdout0_14ck193 = 0 time = 970
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=970.025n

* CHECK dout0_15 Vdout0_15ck193 = 0 time = 970
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=970.025n

* CHECK dout0_16 Vdout0_16ck193 = 1.1 time = 970
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=970.025n

* CHECK dout0_17 Vdout0_17ck193 = 0 time = 970
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=970.025n

* CHECK dout0_18 Vdout0_18ck193 = 1.1 time = 970
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=970.025n

* CHECK dout0_19 Vdout0_19ck193 = 1.1 time = 970
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=970.025n

* CHECK dout0_20 Vdout0_20ck193 = 1.1 time = 970
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=970.025n

* CHECK dout0_21 Vdout0_21ck193 = 1.1 time = 970
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=970.025n

* CHECK dout0_22 Vdout0_22ck193 = 1.1 time = 970
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=970.025n

* CHECK dout0_23 Vdout0_23ck193 = 0 time = 970
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=970.025n

* CHECK dout0_24 Vdout0_24ck193 = 0 time = 970
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=970.025n

* CHECK dout0_25 Vdout0_25ck193 = 0 time = 970
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=970.025n

* CHECK dout0_26 Vdout0_26ck193 = 0 time = 970
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=970.025n

* CHECK dout0_27 Vdout0_27ck193 = 0 time = 970
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=970.025n

* CHECK dout0_28 Vdout0_28ck193 = 0 time = 970
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=970.025n

* CHECK dout0_29 Vdout0_29ck193 = 1.1 time = 970
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=970.025n

* CHECK dout0_30 Vdout0_30ck193 = 0 time = 970
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=970.025n

* CHECK dout0_31 Vdout0_31ck193 = 1.1 time = 970
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=970.025n

* CHECK dout0_0 Vdout0_0ck195 = 0 time = 980
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=980.025n

* CHECK dout0_1 Vdout0_1ck195 = 0 time = 980
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=980.025n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 980
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=980.025n

* CHECK dout0_3 Vdout0_3ck195 = 1.1 time = 980
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=980.025n

* CHECK dout0_4 Vdout0_4ck195 = 0 time = 980
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=980.025n

* CHECK dout0_5 Vdout0_5ck195 = 0 time = 980
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=980.025n

* CHECK dout0_6 Vdout0_6ck195 = 1.1 time = 980
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=980.025n

* CHECK dout0_7 Vdout0_7ck195 = 1.1 time = 980
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=980.025n

* CHECK dout0_8 Vdout0_8ck195 = 1.1 time = 980
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=980.025n

* CHECK dout0_9 Vdout0_9ck195 = 1.1 time = 980
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=980.025n

* CHECK dout0_10 Vdout0_10ck195 = 0 time = 980
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=980.025n

* CHECK dout0_11 Vdout0_11ck195 = 1.1 time = 980
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=980.025n

* CHECK dout0_12 Vdout0_12ck195 = 1.1 time = 980
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=980.025n

* CHECK dout0_13 Vdout0_13ck195 = 1.1 time = 980
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=980.025n

* CHECK dout0_14 Vdout0_14ck195 = 1.1 time = 980
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=980.025n

* CHECK dout0_15 Vdout0_15ck195 = 1.1 time = 980
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=980.025n

* CHECK dout0_16 Vdout0_16ck195 = 0 time = 980
.meas tran vdout0_16ck195 FIND v(dout0_16) AT=980.025n

* CHECK dout0_17 Vdout0_17ck195 = 0 time = 980
.meas tran vdout0_17ck195 FIND v(dout0_17) AT=980.025n

* CHECK dout0_18 Vdout0_18ck195 = 0 time = 980
.meas tran vdout0_18ck195 FIND v(dout0_18) AT=980.025n

* CHECK dout0_19 Vdout0_19ck195 = 0 time = 980
.meas tran vdout0_19ck195 FIND v(dout0_19) AT=980.025n

* CHECK dout0_20 Vdout0_20ck195 = 0 time = 980
.meas tran vdout0_20ck195 FIND v(dout0_20) AT=980.025n

* CHECK dout0_21 Vdout0_21ck195 = 1.1 time = 980
.meas tran vdout0_21ck195 FIND v(dout0_21) AT=980.025n

* CHECK dout0_22 Vdout0_22ck195 = 1.1 time = 980
.meas tran vdout0_22ck195 FIND v(dout0_22) AT=980.025n

* CHECK dout0_23 Vdout0_23ck195 = 1.1 time = 980
.meas tran vdout0_23ck195 FIND v(dout0_23) AT=980.025n

* CHECK dout0_24 Vdout0_24ck195 = 0 time = 980
.meas tran vdout0_24ck195 FIND v(dout0_24) AT=980.025n

* CHECK dout0_25 Vdout0_25ck195 = 0 time = 980
.meas tran vdout0_25ck195 FIND v(dout0_25) AT=980.025n

* CHECK dout0_26 Vdout0_26ck195 = 1.1 time = 980
.meas tran vdout0_26ck195 FIND v(dout0_26) AT=980.025n

* CHECK dout0_27 Vdout0_27ck195 = 0 time = 980
.meas tran vdout0_27ck195 FIND v(dout0_27) AT=980.025n

* CHECK dout0_28 Vdout0_28ck195 = 0 time = 980
.meas tran vdout0_28ck195 FIND v(dout0_28) AT=980.025n

* CHECK dout0_29 Vdout0_29ck195 = 1.1 time = 980
.meas tran vdout0_29ck195 FIND v(dout0_29) AT=980.025n

* CHECK dout0_30 Vdout0_30ck195 = 1.1 time = 980
.meas tran vdout0_30ck195 FIND v(dout0_30) AT=980.025n

* CHECK dout0_31 Vdout0_31ck195 = 0 time = 980
.meas tran vdout0_31ck195 FIND v(dout0_31) AT=980.025n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 990
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=990.025n

* CHECK dout0_1 Vdout0_1ck197 = 1.1 time = 990
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=990.025n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 990
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=990.025n

* CHECK dout0_3 Vdout0_3ck197 = 0 time = 990
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=990.025n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 990
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=990.025n

* CHECK dout0_5 Vdout0_5ck197 = 0 time = 990
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=990.025n

* CHECK dout0_6 Vdout0_6ck197 = 1.1 time = 990
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=990.025n

* CHECK dout0_7 Vdout0_7ck197 = 1.1 time = 990
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=990.025n

* CHECK dout0_8 Vdout0_8ck197 = 1.1 time = 990
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=990.025n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 990
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=990.025n

* CHECK dout0_10 Vdout0_10ck197 = 0 time = 990
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=990.025n

* CHECK dout0_11 Vdout0_11ck197 = 0 time = 990
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=990.025n

* CHECK dout0_12 Vdout0_12ck197 = 1.1 time = 990
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=990.025n

* CHECK dout0_13 Vdout0_13ck197 = 0 time = 990
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=990.025n

* CHECK dout0_14 Vdout0_14ck197 = 0 time = 990
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=990.025n

* CHECK dout0_15 Vdout0_15ck197 = 0 time = 990
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=990.025n

* CHECK dout0_16 Vdout0_16ck197 = 0 time = 990
.meas tran vdout0_16ck197 FIND v(dout0_16) AT=990.025n

* CHECK dout0_17 Vdout0_17ck197 = 1.1 time = 990
.meas tran vdout0_17ck197 FIND v(dout0_17) AT=990.025n

* CHECK dout0_18 Vdout0_18ck197 = 1.1 time = 990
.meas tran vdout0_18ck197 FIND v(dout0_18) AT=990.025n

* CHECK dout0_19 Vdout0_19ck197 = 1.1 time = 990
.meas tran vdout0_19ck197 FIND v(dout0_19) AT=990.025n

* CHECK dout0_20 Vdout0_20ck197 = 0 time = 990
.meas tran vdout0_20ck197 FIND v(dout0_20) AT=990.025n

* CHECK dout0_21 Vdout0_21ck197 = 1.1 time = 990
.meas tran vdout0_21ck197 FIND v(dout0_21) AT=990.025n

* CHECK dout0_22 Vdout0_22ck197 = 1.1 time = 990
.meas tran vdout0_22ck197 FIND v(dout0_22) AT=990.025n

* CHECK dout0_23 Vdout0_23ck197 = 0 time = 990
.meas tran vdout0_23ck197 FIND v(dout0_23) AT=990.025n

* CHECK dout0_24 Vdout0_24ck197 = 0 time = 990
.meas tran vdout0_24ck197 FIND v(dout0_24) AT=990.025n

* CHECK dout0_25 Vdout0_25ck197 = 0 time = 990
.meas tran vdout0_25ck197 FIND v(dout0_25) AT=990.025n

* CHECK dout0_26 Vdout0_26ck197 = 1.1 time = 990
.meas tran vdout0_26ck197 FIND v(dout0_26) AT=990.025n

* CHECK dout0_27 Vdout0_27ck197 = 1.1 time = 990
.meas tran vdout0_27ck197 FIND v(dout0_27) AT=990.025n

* CHECK dout0_28 Vdout0_28ck197 = 0 time = 990
.meas tran vdout0_28ck197 FIND v(dout0_28) AT=990.025n

* CHECK dout0_29 Vdout0_29ck197 = 0 time = 990
.meas tran vdout0_29ck197 FIND v(dout0_29) AT=990.025n

* CHECK dout0_30 Vdout0_30ck197 = 1.1 time = 990
.meas tran vdout0_30ck197 FIND v(dout0_30) AT=990.025n

* CHECK dout0_31 Vdout0_31ck197 = 1.1 time = 990
.meas tran vdout0_31ck197 FIND v(dout0_31) AT=990.025n

* CHECK dout0_0 Vdout0_0ck198 = 0 time = 995
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=995.025n

* CHECK dout0_1 Vdout0_1ck198 = 1.1 time = 995
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=995.025n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 995
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=995.025n

* CHECK dout0_3 Vdout0_3ck198 = 1.1 time = 995
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=995.025n

* CHECK dout0_4 Vdout0_4ck198 = 1.1 time = 995
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=995.025n

* CHECK dout0_5 Vdout0_5ck198 = 1.1 time = 995
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=995.025n

* CHECK dout0_6 Vdout0_6ck198 = 1.1 time = 995
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=995.025n

* CHECK dout0_7 Vdout0_7ck198 = 0 time = 995
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=995.025n

* CHECK dout0_8 Vdout0_8ck198 = 1.1 time = 995
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=995.025n

* CHECK dout0_9 Vdout0_9ck198 = 1.1 time = 995
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=995.025n

* CHECK dout0_10 Vdout0_10ck198 = 0 time = 995
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=995.025n

* CHECK dout0_11 Vdout0_11ck198 = 1.1 time = 995
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=995.025n

* CHECK dout0_12 Vdout0_12ck198 = 0 time = 995
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=995.025n

* CHECK dout0_13 Vdout0_13ck198 = 1.1 time = 995
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=995.025n

* CHECK dout0_14 Vdout0_14ck198 = 0 time = 995
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=995.025n

* CHECK dout0_15 Vdout0_15ck198 = 0 time = 995
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=995.025n

* CHECK dout0_16 Vdout0_16ck198 = 1.1 time = 995
.meas tran vdout0_16ck198 FIND v(dout0_16) AT=995.025n

* CHECK dout0_17 Vdout0_17ck198 = 0 time = 995
.meas tran vdout0_17ck198 FIND v(dout0_17) AT=995.025n

* CHECK dout0_18 Vdout0_18ck198 = 0 time = 995
.meas tran vdout0_18ck198 FIND v(dout0_18) AT=995.025n

* CHECK dout0_19 Vdout0_19ck198 = 1.1 time = 995
.meas tran vdout0_19ck198 FIND v(dout0_19) AT=995.025n

* CHECK dout0_20 Vdout0_20ck198 = 0 time = 995
.meas tran vdout0_20ck198 FIND v(dout0_20) AT=995.025n

* CHECK dout0_21 Vdout0_21ck198 = 0 time = 995
.meas tran vdout0_21ck198 FIND v(dout0_21) AT=995.025n

* CHECK dout0_22 Vdout0_22ck198 = 0 time = 995
.meas tran vdout0_22ck198 FIND v(dout0_22) AT=995.025n

* CHECK dout0_23 Vdout0_23ck198 = 0 time = 995
.meas tran vdout0_23ck198 FIND v(dout0_23) AT=995.025n

* CHECK dout0_24 Vdout0_24ck198 = 0 time = 995
.meas tran vdout0_24ck198 FIND v(dout0_24) AT=995.025n

* CHECK dout0_25 Vdout0_25ck198 = 1.1 time = 995
.meas tran vdout0_25ck198 FIND v(dout0_25) AT=995.025n

* CHECK dout0_26 Vdout0_26ck198 = 1.1 time = 995
.meas tran vdout0_26ck198 FIND v(dout0_26) AT=995.025n

* CHECK dout0_27 Vdout0_27ck198 = 1.1 time = 995
.meas tran vdout0_27ck198 FIND v(dout0_27) AT=995.025n

* CHECK dout0_28 Vdout0_28ck198 = 0 time = 995
.meas tran vdout0_28ck198 FIND v(dout0_28) AT=995.025n

* CHECK dout0_29 Vdout0_29ck198 = 0 time = 995
.meas tran vdout0_29ck198 FIND v(dout0_29) AT=995.025n

* CHECK dout0_30 Vdout0_30ck198 = 1.1 time = 995
.meas tran vdout0_30ck198 FIND v(dout0_30) AT=995.025n

* CHECK dout0_31 Vdout0_31ck198 = 0 time = 995
.meas tran vdout0_31ck198 FIND v(dout0_31) AT=995.025n

* CHECK dout0_0 Vdout0_0ck199 = 0 time = 1000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=1000.025n

* CHECK dout0_1 Vdout0_1ck199 = 1.1 time = 1000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=1000.025n

* CHECK dout0_2 Vdout0_2ck199 = 1.1 time = 1000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=1000.025n

* CHECK dout0_3 Vdout0_3ck199 = 1.1 time = 1000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=1000.025n

* CHECK dout0_4 Vdout0_4ck199 = 0 time = 1000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=1000.025n

* CHECK dout0_5 Vdout0_5ck199 = 0 time = 1000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=1000.025n

* CHECK dout0_6 Vdout0_6ck199 = 1.1 time = 1000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=1000.025n

* CHECK dout0_7 Vdout0_7ck199 = 1.1 time = 1000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=1000.025n

* CHECK dout0_8 Vdout0_8ck199 = 0 time = 1000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=1000.025n

* CHECK dout0_9 Vdout0_9ck199 = 0 time = 1000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=1000.025n

* CHECK dout0_10 Vdout0_10ck199 = 1.1 time = 1000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=1000.025n

* CHECK dout0_11 Vdout0_11ck199 = 1.1 time = 1000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=1000.025n

* CHECK dout0_12 Vdout0_12ck199 = 0 time = 1000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=1000.025n

* CHECK dout0_13 Vdout0_13ck199 = 1.1 time = 1000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=1000.025n

* CHECK dout0_14 Vdout0_14ck199 = 0 time = 1000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=1000.025n

* CHECK dout0_15 Vdout0_15ck199 = 1.1 time = 1000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=1000.025n

* CHECK dout0_16 Vdout0_16ck199 = 0 time = 1000
.meas tran vdout0_16ck199 FIND v(dout0_16) AT=1000.025n

* CHECK dout0_17 Vdout0_17ck199 = 0 time = 1000
.meas tran vdout0_17ck199 FIND v(dout0_17) AT=1000.025n

* CHECK dout0_18 Vdout0_18ck199 = 1.1 time = 1000
.meas tran vdout0_18ck199 FIND v(dout0_18) AT=1000.025n

* CHECK dout0_19 Vdout0_19ck199 = 1.1 time = 1000
.meas tran vdout0_19ck199 FIND v(dout0_19) AT=1000.025n

* CHECK dout0_20 Vdout0_20ck199 = 1.1 time = 1000
.meas tran vdout0_20ck199 FIND v(dout0_20) AT=1000.025n

* CHECK dout0_21 Vdout0_21ck199 = 0 time = 1000
.meas tran vdout0_21ck199 FIND v(dout0_21) AT=1000.025n

* CHECK dout0_22 Vdout0_22ck199 = 1.1 time = 1000
.meas tran vdout0_22ck199 FIND v(dout0_22) AT=1000.025n

* CHECK dout0_23 Vdout0_23ck199 = 0 time = 1000
.meas tran vdout0_23ck199 FIND v(dout0_23) AT=1000.025n

* CHECK dout0_24 Vdout0_24ck199 = 1.1 time = 1000
.meas tran vdout0_24ck199 FIND v(dout0_24) AT=1000.025n

* CHECK dout0_25 Vdout0_25ck199 = 1.1 time = 1000
.meas tran vdout0_25ck199 FIND v(dout0_25) AT=1000.025n

* CHECK dout0_26 Vdout0_26ck199 = 1.1 time = 1000
.meas tran vdout0_26ck199 FIND v(dout0_26) AT=1000.025n

* CHECK dout0_27 Vdout0_27ck199 = 1.1 time = 1000
.meas tran vdout0_27ck199 FIND v(dout0_27) AT=1000.025n

* CHECK dout0_28 Vdout0_28ck199 = 1.1 time = 1000
.meas tran vdout0_28ck199 FIND v(dout0_28) AT=1000.025n

* CHECK dout0_29 Vdout0_29ck199 = 1.1 time = 1000
.meas tran vdout0_29ck199 FIND v(dout0_29) AT=1000.025n

* CHECK dout0_30 Vdout0_30ck199 = 0 time = 1000
.meas tran vdout0_30ck199 FIND v(dout0_30) AT=1000.025n

* CHECK dout0_31 Vdout0_31ck199 = 0 time = 1000
.meas tran vdout0_31ck199 FIND v(dout0_31) AT=1000.025n

* CHECK dout0_0 Vdout0_0ck200 = 0 time = 1005
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=1005.025n

* CHECK dout0_1 Vdout0_1ck200 = 1.1 time = 1005
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=1005.025n

* CHECK dout0_2 Vdout0_2ck200 = 0 time = 1005
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=1005.025n

* CHECK dout0_3 Vdout0_3ck200 = 0 time = 1005
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=1005.025n

* CHECK dout0_4 Vdout0_4ck200 = 0 time = 1005
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=1005.025n

* CHECK dout0_5 Vdout0_5ck200 = 0 time = 1005
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=1005.025n

* CHECK dout0_6 Vdout0_6ck200 = 1.1 time = 1005
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=1005.025n

* CHECK dout0_7 Vdout0_7ck200 = 1.1 time = 1005
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=1005.025n

* CHECK dout0_8 Vdout0_8ck200 = 1.1 time = 1005
.meas tran vdout0_8ck200 FIND v(dout0_8) AT=1005.025n

* CHECK dout0_9 Vdout0_9ck200 = 0 time = 1005
.meas tran vdout0_9ck200 FIND v(dout0_9) AT=1005.025n

* CHECK dout0_10 Vdout0_10ck200 = 0 time = 1005
.meas tran vdout0_10ck200 FIND v(dout0_10) AT=1005.025n

* CHECK dout0_11 Vdout0_11ck200 = 0 time = 1005
.meas tran vdout0_11ck200 FIND v(dout0_11) AT=1005.025n

* CHECK dout0_12 Vdout0_12ck200 = 1.1 time = 1005
.meas tran vdout0_12ck200 FIND v(dout0_12) AT=1005.025n

* CHECK dout0_13 Vdout0_13ck200 = 0 time = 1005
.meas tran vdout0_13ck200 FIND v(dout0_13) AT=1005.025n

* CHECK dout0_14 Vdout0_14ck200 = 0 time = 1005
.meas tran vdout0_14ck200 FIND v(dout0_14) AT=1005.025n

* CHECK dout0_15 Vdout0_15ck200 = 0 time = 1005
.meas tran vdout0_15ck200 FIND v(dout0_15) AT=1005.025n

* CHECK dout0_16 Vdout0_16ck200 = 0 time = 1005
.meas tran vdout0_16ck200 FIND v(dout0_16) AT=1005.025n

* CHECK dout0_17 Vdout0_17ck200 = 1.1 time = 1005
.meas tran vdout0_17ck200 FIND v(dout0_17) AT=1005.025n

* CHECK dout0_18 Vdout0_18ck200 = 1.1 time = 1005
.meas tran vdout0_18ck200 FIND v(dout0_18) AT=1005.025n

* CHECK dout0_19 Vdout0_19ck200 = 1.1 time = 1005
.meas tran vdout0_19ck200 FIND v(dout0_19) AT=1005.025n

* CHECK dout0_20 Vdout0_20ck200 = 0 time = 1005
.meas tran vdout0_20ck200 FIND v(dout0_20) AT=1005.025n

* CHECK dout0_21 Vdout0_21ck200 = 1.1 time = 1005
.meas tran vdout0_21ck200 FIND v(dout0_21) AT=1005.025n

* CHECK dout0_22 Vdout0_22ck200 = 1.1 time = 1005
.meas tran vdout0_22ck200 FIND v(dout0_22) AT=1005.025n

* CHECK dout0_23 Vdout0_23ck200 = 0 time = 1005
.meas tran vdout0_23ck200 FIND v(dout0_23) AT=1005.025n

* CHECK dout0_24 Vdout0_24ck200 = 0 time = 1005
.meas tran vdout0_24ck200 FIND v(dout0_24) AT=1005.025n

* CHECK dout0_25 Vdout0_25ck200 = 0 time = 1005
.meas tran vdout0_25ck200 FIND v(dout0_25) AT=1005.025n

* CHECK dout0_26 Vdout0_26ck200 = 1.1 time = 1005
.meas tran vdout0_26ck200 FIND v(dout0_26) AT=1005.025n

* CHECK dout0_27 Vdout0_27ck200 = 1.1 time = 1005
.meas tran vdout0_27ck200 FIND v(dout0_27) AT=1005.025n

* CHECK dout0_28 Vdout0_28ck200 = 0 time = 1005
.meas tran vdout0_28ck200 FIND v(dout0_28) AT=1005.025n

* CHECK dout0_29 Vdout0_29ck200 = 0 time = 1005
.meas tran vdout0_29ck200 FIND v(dout0_29) AT=1005.025n

* CHECK dout0_30 Vdout0_30ck200 = 1.1 time = 1005
.meas tran vdout0_30ck200 FIND v(dout0_30) AT=1005.025n

* CHECK dout0_31 Vdout0_31ck200 = 1.1 time = 1005
.meas tran vdout0_31ck200 FIND v(dout0_31) AT=1005.025n

* CHECK dout0_0 Vdout0_0ck201 = 0 time = 1010
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=1010.025n

* CHECK dout0_1 Vdout0_1ck201 = 1.1 time = 1010
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=1010.025n

* CHECK dout0_2 Vdout0_2ck201 = 0 time = 1010
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=1010.025n

* CHECK dout0_3 Vdout0_3ck201 = 1.1 time = 1010
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=1010.025n

* CHECK dout0_4 Vdout0_4ck201 = 1.1 time = 1010
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=1010.025n

* CHECK dout0_5 Vdout0_5ck201 = 1.1 time = 1010
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=1010.025n

* CHECK dout0_6 Vdout0_6ck201 = 1.1 time = 1010
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=1010.025n

* CHECK dout0_7 Vdout0_7ck201 = 0 time = 1010
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=1010.025n

* CHECK dout0_8 Vdout0_8ck201 = 1.1 time = 1010
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=1010.025n

* CHECK dout0_9 Vdout0_9ck201 = 1.1 time = 1010
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=1010.025n

* CHECK dout0_10 Vdout0_10ck201 = 0 time = 1010
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=1010.025n

* CHECK dout0_11 Vdout0_11ck201 = 1.1 time = 1010
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=1010.025n

* CHECK dout0_12 Vdout0_12ck201 = 0 time = 1010
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=1010.025n

* CHECK dout0_13 Vdout0_13ck201 = 1.1 time = 1010
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=1010.025n

* CHECK dout0_14 Vdout0_14ck201 = 0 time = 1010
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=1010.025n

* CHECK dout0_15 Vdout0_15ck201 = 0 time = 1010
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=1010.025n

* CHECK dout0_16 Vdout0_16ck201 = 1.1 time = 1010
.meas tran vdout0_16ck201 FIND v(dout0_16) AT=1010.025n

* CHECK dout0_17 Vdout0_17ck201 = 0 time = 1010
.meas tran vdout0_17ck201 FIND v(dout0_17) AT=1010.025n

* CHECK dout0_18 Vdout0_18ck201 = 0 time = 1010
.meas tran vdout0_18ck201 FIND v(dout0_18) AT=1010.025n

* CHECK dout0_19 Vdout0_19ck201 = 1.1 time = 1010
.meas tran vdout0_19ck201 FIND v(dout0_19) AT=1010.025n

* CHECK dout0_20 Vdout0_20ck201 = 0 time = 1010
.meas tran vdout0_20ck201 FIND v(dout0_20) AT=1010.025n

* CHECK dout0_21 Vdout0_21ck201 = 0 time = 1010
.meas tran vdout0_21ck201 FIND v(dout0_21) AT=1010.025n

* CHECK dout0_22 Vdout0_22ck201 = 0 time = 1010
.meas tran vdout0_22ck201 FIND v(dout0_22) AT=1010.025n

* CHECK dout0_23 Vdout0_23ck201 = 0 time = 1010
.meas tran vdout0_23ck201 FIND v(dout0_23) AT=1010.025n

* CHECK dout0_24 Vdout0_24ck201 = 0 time = 1010
.meas tran vdout0_24ck201 FIND v(dout0_24) AT=1010.025n

* CHECK dout0_25 Vdout0_25ck201 = 1.1 time = 1010
.meas tran vdout0_25ck201 FIND v(dout0_25) AT=1010.025n

* CHECK dout0_26 Vdout0_26ck201 = 1.1 time = 1010
.meas tran vdout0_26ck201 FIND v(dout0_26) AT=1010.025n

* CHECK dout0_27 Vdout0_27ck201 = 1.1 time = 1010
.meas tran vdout0_27ck201 FIND v(dout0_27) AT=1010.025n

* CHECK dout0_28 Vdout0_28ck201 = 0 time = 1010
.meas tran vdout0_28ck201 FIND v(dout0_28) AT=1010.025n

* CHECK dout0_29 Vdout0_29ck201 = 0 time = 1010
.meas tran vdout0_29ck201 FIND v(dout0_29) AT=1010.025n

* CHECK dout0_30 Vdout0_30ck201 = 1.1 time = 1010
.meas tran vdout0_30ck201 FIND v(dout0_30) AT=1010.025n

* CHECK dout0_31 Vdout0_31ck201 = 0 time = 1010
.meas tran vdout0_31ck201 FIND v(dout0_31) AT=1010.025n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
